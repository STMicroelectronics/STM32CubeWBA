# Keil uVision project Project_s.uvprojx, settings and files
target STM32WBA65I-DK1_Templates_OEMiROT_Appli_TrustZone (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.4.0
  cpu: IROM(0x0C000000-0xC07FFFF) IROM2(0x0C07E000-0xC07FFFF) IRAM(0x30000000-0x3000FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project_s +hex
  AfterMake: fromelf #L --bincombined --output=$L"\..\..\..\Binary\oemirot_tz_s_app.bin"
  AfterMake: ..\postbuild.bat "secure"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA65xx,USE_HAL_DRIVER,USER_VECT_TAB_ADDRESS
  c include: ../../Secure/Inc;../../Secure_nsclib;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../../Drivers/BSP/Components/Common
  memory RVCT4: ROM 0xc000000 size 0x80000
  memory RVCT9: RAM 0x30000000 size 0x10000
  scatter file: stm32wba65xx_flash_s.sct
  link misc: --predefine=-I..\..\Secure_nsclib
--predefine=-DSTM32WBA65xx
--import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32wbaxx_s.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_irda.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_smartcard.c stm32wbaxx_hal_smartcard_ex.c stm32wbaxx_hal_smbus.c stm32wbaxx_hal_smbus_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_tsc.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_hal_wwdg.c
  group Example/MDK-ARM
    ../: startup_stm32wba65xx.s
  group Example/User
    ../../Secure/Src/: main.c secure_nsc.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
software components: CMSIS:CORE 4.3.0
