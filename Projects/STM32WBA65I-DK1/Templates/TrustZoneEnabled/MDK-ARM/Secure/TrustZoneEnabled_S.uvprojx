# Keil uVision project TrustZoneEnabled_S.uvprojx, settings and files
target TrustZoneEnabled_S (6210000::V6.21::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.5.0
  cpu: IRAM(0x20040000-0x2007FFFF) IROM(0x08100000-0x81FFFFF) IROM2(0x0C0FE000-0xC0FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: TrustZoneEnabled_S +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA65xx
  c include: ../../Secure/Inc;../../Secure_nsclib;../../../../../../Drivers/BSP/STM32WBA65I-DK1;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT5: ROM 0xc0fe000 size 0x2000
  memory RVCT9: RAM 0x20040000 size 0x40000
  scatter file: stm32wba65xx_flash_s.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba65xx.s
  group Application/User/Secure
    ../../Secure/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_icache.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32wbaxx_s.c
software components: CMSIS:CORE 5.6.0
