# IAR project TrustZoneEnabled_NoIsolation.ewp, settings and files
configuration TrustZoneEnabled_NoIsolation (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA65xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/STM32WBA65I-DK1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneEnabled_NoIsolation.hex
  ILINK.IlinkOutputFile: TrustZoneEnabled_NoIsolation.out
  ILINK.IlinkIcfFile: stm32wba65xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba65xx.s
  group Application/User
    ../Src/: main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c
