# Keil uVision project SAI_AudioPlay.uvprojx, settings and files
target SAI_AudioPlay (6210000::V6.21::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: SAI_AudioPlay +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA65xx
  c include: ../Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32WBA65I-DK1;../../../../../../Drivers/BSP/Components/wm8904
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: stm32wba65xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba65xx.s
  group Application/User
    ../Src/: main.c linked_list.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/cs42l51/: cs42l51_reg.c cs42l51.c
    ../../../../../../Drivers/BSP/Components/wm8904/: wm8904_reg.c wm8904.c
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery_bus.c stm32wba65i_discovery.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
software components: CMSIS:CORE 5.6.0
