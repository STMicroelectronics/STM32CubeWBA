# Keil uVision project Zigbee_Thermostat_Server_Router.uvprojx, settings and files
target Zigbee_Thermostat_Server_Router (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Zigbee_Thermostat_Server_Router +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32,STM32WBA,STM32WBA65xx,STM32WBA65RIx,USE_HAL_DRIVER,USE_FULL_ASSERT,USE_FULL_LL_DRIVER,MAC,MAC_LAYER,APPLICATION_USE_BAREMETAL,APPLICATION_USE_NUCLEO,APPLICATION_USE_HW_AES,APPLICATION_USE_HW_RNG,DISABLE_RFTS_EXT_EVNT_HNDLR=1,CONFIG_ZB_REV=23
  c misc: -fshort-enums
  c include: ../Core/Inc;../STM32_WPAN/App;../STM32_WPAN/Target;../System/Config;../System/Config/CRC_Ctrl;../System/Config/Debug_GPIO;../System/Config/Log;../System/Config/LowPower;../System/Interfaces;../../../../../../Projects/Common/WPAN/Interfaces;../../../../../../Projects/Common/WPAN/Modules;../../../../../../Projects/Common/WPAN/Modules/BasicAES;../../../../../../Projects/Common/WPAN/Modules/Flash;../../../../../../Projects/Common/WPAN/Modules/Log;../../../../../../Projects/Common/WPAN/Modules/MemoryManager;../../../../../../Projects/Common/WPAN/Modules/RTDebug;../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/STM32WBA65I-DK1;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port/stm32wba;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port/mac;../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ieee_15_4_basic;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../../../../../../Middlewares/ST/STM32_WPAN/utilities;../../../../../../Middlewares/ST/STM32_WPAN/interface;../../../../../../Utilities/conf;../../../../../../Utilities/LCD;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/tim_serv;../../../../../../Utilities/trace/adv_trace;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zgp;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/se;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/general;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/key;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/se;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/security;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/zd;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack;../../../../../../Drivers/BSP/Components/ssd1315
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32wba65xx_flash.sct
  link misc: --diag_suppress L6314W

--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: app_menu.c main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_zigbee_endpoint.c app_zigbee.c app_zigbee_utility.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: power_table.c linklayer_plat.c ll_sys_if.c mac_sys_if.c zigbee_plat.c zigbee_sys_if.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Common/WPAN/Interface
    ../../../../../../Projects/Common/WPAN/Interfaces/: app_bsp.c adv_trace_usart_if.c hw_aes.c hw_otp.c hw_rng.c timer_if.c
  group Doc
    ../: readme.md README.md
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c stm32wba65i_discovery_bus.c stm32wba65i_discovery_lcd.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_pka.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_utils.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Common/WPAN/Modules
    ../../../../../../Projects/Common/WPAN/Modules/: app_sys.c crc_ctrl.c otp.c scm.c stm_list.c stm_queue.c wpan_utils.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/Log
    ../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_MDK-ARM.s
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Utilities
    ../../../../../../Utilities/LCD/: stm32_lcd.c
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Middlewares/STM32_WPAN/LinkLayer
    ./: 
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/802_15_4_ll_porting/: mac_radio_port.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_802_15_4_V3_0.a Mac15_4.a
  group Middlewares/STM32_WPAN/Mac_802_15_4
    ./: 
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/STM32_WPAN/Zigbee
    ./: 
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/: ZigBeeProR23_FFD.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/: ZigBeeClusters.a
software components: CMSIS:CORE 4.3.0
