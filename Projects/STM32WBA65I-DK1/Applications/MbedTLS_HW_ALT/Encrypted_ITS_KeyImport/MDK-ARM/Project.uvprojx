# Keil uVision project Project.uvprojx, settings and files
target STM32WBA65I-DK1_Encrypted_ITS_KeyImport (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.5.0-RC2
  cpu: IRAM(0x20000000-0x2007FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA65xx,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>,MBEDTLS_USER_CONFIG_FILE=<mbedtls_alt_config.h>,USE_HUK,USE_FULL_ASSERT
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32WBA65I-DK1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns;../../../../../../Middlewares/Third_Party/mbedtls/include;../../../../../../Middlewares/Third_Party/mbedtls/include/mbedtls;../../../../../../Middlewares/Third_Party/mbedtls/include/psa;../../../../../../Middlewares/Third_Party/mbedtls/library;../../../../../../Drivers/BSP/STM32WBA65I-DK1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: stm32wba65xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/User
    ../Src/: stm32wbaxx_it.c stm32wbaxx_hal_msp.c main.c storage_interface.c
  group Doc
    ../: README.md
  group Middlewares/ST/mbedtls_alt
    ../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns/: entropy_hardware_alt.c aes_alt.c gcm_alt.c psa_its_alt.c
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_ecp.c psa_its_file.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: psa_crypto_hash.c aes.c psa_crypto.c psa_crypto_mac.c psa_crypto_slot_management.c psa_crypto_storage.c psa_crypto_aead.c md.c platform_util.c sha256.c cipher.c cipher_wrap.c ctr_drbg.c entropy.c platform.c constant_time.c psa_its_file.c psa_crypto_random.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Example/MDK-ARM
    ./: startup_stm32wba65xx.s
software components: CMSIS:CORE 5.6.0
