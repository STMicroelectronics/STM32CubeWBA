# Keil uVision project Ux_Device_Audio20_MultiChannel.uvprojx, settings and files
target Ux_Device_Audio20_MultiChannel (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2006FFFF) IRAM2(0x20070000-0x2007FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Ux_Device_Audio20_MultiChannel +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_AUDIO_CODEC_WM8904,TX_EXECUTION_PROFILE_ENABLE,TX_INCLUDE_USER_DEFINE_FILE,TX_SINGLE_MODE_NON_SECURE=1,UX_INCLUDE_USER_DEFINE_FILE,USE_HAL_DRIVER,STM32WBA65xx
  c include: ../Core/Inc;../AZURE_RTOS/App;../USBX/App;../USBX/Target;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/threadx/common/inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/inc;../../../../../../Middlewares/ST/usbx/common/core/inc;../../../../../../Middlewares/ST/usbx/ports/generic/inc;../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WBA65I-DK1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/wm8904
  asm define: TX_SINGLE_MODE_NON_SECURE=1,TX_EXECUTION_PROFILE_ENABLE
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x20070000 size 0x10000
  scatter file: stm32wba65xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: main.c tx_initialize_low_level.S app_threadx.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c stm32wbaxx_hal_timebase_tim.c
  group Application/User/USBX/App
    ../USBX/App/: ux_device_descriptors.c app_usbx_device.c app_usbx.c ux_device_audio.c ux_device_audio_play.c ux_device_audio_record.c tx_execution_profile.c
  group Application/User/AZURE_RTOS/App
    ../AZURE_RTOS/App/: app_azure_rtos.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c stm32wba65i_discovery_audio.c stm32wba65i_discovery_bus.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_pcd.c stm32wbaxx_hal_pcd_ex.c stm32wbaxx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/ThreadX/Core
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_thread_stack_error_handler.c tx_thread_stack_error_notify.c tx_thread_system_resume.c tx_block_allocate.c tx_block_pool_cleanup.c tx_block_pool_create.c tx_block_pool_delete.c tx_block_pool_info_get.c tx_block_pool_initialize.c tx_block_pool_prioritize.c tx_block_release.c tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_delete.c tx_byte_pool_info_get.c tx_byte_pool_initialize.c tx_byte_pool_prioritize.c tx_byte_pool_search.c tx_byte_release.c tx_event_flags_cleanup.c tx_event_flags_create.c tx_event_flags_delete.c tx_event_flags_get.c tx_event_flags_info_get.c tx_event_flags_initialize.c tx_event_flags_set.c tx_event_flags_set_notify.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_info_get.c tx_mutex_initialize.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_queue_cleanup.c tx_queue_create.c tx_queue_delete.c tx_queue_flush.c tx_queue_front_send.c tx_queue_info_get.c tx_queue_initialize.c tx_queue_prioritize.c tx_queue_receive.c tx_queue_send.c tx_queue_send_notify.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_delete.c tx_semaphore_get.c tx_semaphore_info_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_semaphore_put_notify.c tx_thread_create.c tx_thread_delete.c tx_thread_entry_exit_notify.c tx_thread_identify.c tx_thread_info_get.c tx_thread_initialize.c tx_thread_preemption_change.c tx_thread_priority_change.c tx_thread_relinquish.c tx_thread_reset.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_stack_analyze.c tx_thread_suspend.c tx_thread_system_preempt_check.c tx_thread_system_suspend.c tx_thread_terminate.c tx_thread_time_slice.c tx_thread_time_slice_change.c tx_thread_timeout.c tx_thread_wait_abort.c tx_time_get.c tx_time_set.c txe_block_allocate.c txe_block_pool_create.c txe_block_pool_delete.c txe_block_pool_info_get.c txe_block_pool_prioritize.c txe_block_release.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_pool_delete.c txe_byte_pool_info_get.c txe_byte_pool_prioritize.c txe_byte_release.c txe_event_flags_create.c txe_event_flags_delete.c txe_event_flags_get.c txe_event_flags_info_get.c txe_event_flags_set.c txe_event_flags_set_notify.c txe_mutex_create.c txe_mutex_delete.c txe_mutex_get.c txe_mutex_info_get.c txe_mutex_prioritize.c txe_mutex_put.c txe_queue_create.c txe_queue_delete.c txe_queue_flush.c txe_queue_front_send.c txe_queue_info_get.c txe_queue_prioritize.c txe_queue_receive.c txe_queue_send.c txe_queue_send_notify.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_delete.c txe_semaphore_get.c txe_semaphore_info_get.c txe_semaphore_prioritize.c txe_semaphore_put.c txe_semaphore_put_notify.c txe_thread_create.c txe_thread_delete.c txe_thread_entry_exit_notify.c txe_thread_info_get.c txe_thread_preemption_change.c txe_thread_priority_change.c txe_thread_relinquish.c txe_thread_reset.c txe_thread_resume.c txe_thread_suspend.c txe_thread_terminate.c txe_thread_time_slice_change.c txe_thread_wait_abort.c tx_timer_activate.c tx_timer_change.c tx_timer_create.c tx_timer_deactivate.c tx_timer_delete.c tx_timer_expiration_process.c tx_timer_info_get.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_timer_activate.c txe_timer_change.c txe_timer_create.c txe_timer_deactivate.c txe_timer_delete.c txe_timer_info_get.c
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/ac6/src/: tx_thread_context_restore.S tx_thread_context_save.S tx_thread_interrupt_control.S tx_thread_interrupt_disable.S tx_thread_interrupt_restore.S tx_thread_schedule.S tx_thread_stack_build.S tx_thread_system_return.S tx_timer_interrupt.S
  group Middlewares/USBX/UX Device Controllers
    ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_request.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/Core System
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_event_flags_create.c ux_utility_event_flags_delete.c ux_utility_event_flags_get.c ux_utility_event_flags_set.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_set.c ux_utility_mutex_create.c ux_utility_mutex_delete.c ux_utility_mutex_off.c ux_utility_mutex_on.c ux_utility_physical_address.c ux_utility_semaphore_create.c ux_utility_semaphore_delete.c ux_utility_semaphore_get.c ux_utility_semaphore_put.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_thread_create.c ux_utility_thread_delete.c ux_utility_thread_identify.c ux_utility_thread_relinquish.c ux_utility_thread_resume.c ux_utility_thread_schedule_other.c ux_utility_thread_sleep.c ux_utility_thread_suspend.c ux_utility_timer_create.c ux_utility_timer_delete.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/USBX/UX Device Class AUDIO RECORDING
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_transmission_start.c ux_device_class_audio_write_frame_commit.c ux_device_class_audio_write_frame_get.c ux_device_class_audio_write_thread_entry.c
  group Middlewares/USBX/UX Device CoreStack
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c
  group Middlewares/USBX/UX Device Class AUDIO
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_activate.c ux_device_class_audio_change.c ux_device_class_audio_control_request.c ux_device_class_audio_deactivate.c ux_device_class_audio_entry.c ux_device_class_audio_frame_write.c ux_device_class_audio_initialize.c ux_device_class_audio_ioctl.c ux_device_class_audio_read_thread_entry.c ux_device_class_audio_sample_read8.c ux_device_class_audio_sample_read16.c ux_device_class_audio_sample_read24.c ux_device_class_audio_sample_read32.c ux_device_class_audio_stream_get.c ux_device_class_audio_unitialize.c ux_device_class_audio10_control_process.c ux_device_class_audio20_control_process.c ux_device_class_audio_feedback_get.c ux_device_class_audio_feedback_set.c ux_device_class_audio_feedback_thread_entry.c ux_device_class_audio_interrupt_send.c ux_device_class_audio_interrupt_thread_entry.c ux_device_class_audio_speed_get.c
  group Middlewares/USBX/UX Device Class AUDIO PLAYBACK
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_read_frame_free.c ux_device_class_audio_read_frame_get.c ux_device_class_audio_reception_start.c
software components: CMSIS:CORE 5.6.0
