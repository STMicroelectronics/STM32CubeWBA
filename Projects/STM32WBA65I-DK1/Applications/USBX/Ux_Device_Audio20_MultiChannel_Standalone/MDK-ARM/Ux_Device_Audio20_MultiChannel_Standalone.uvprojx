# Keil uVision project Ux_Device_Audio20_MultiChannel_Standalone.uvprojx, settings and files
target Ux_Device_Audio20_MultiChannel_Standalone (6210000::V6.21::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2006FFFF) IRAM2(0x20070000-0x2007FFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Ux_Device_Audio2_0_MultiChannel_Standalone +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_AUDIO_CODEC_WM8904,TX_INCLUDE_USER_DEFINE_FILE,UX_INCLUDE_USER_DEFINE_FILE,USE_HAL_DRIVER,STM32WBA65xx
  c include: ../USBX/App;../USBX/Target;../Core/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Middlewares/ST/usbx/common/core/inc;../../../../../../Middlewares/ST/usbx/ports/generic/inc;../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers;../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WBA65I-DK1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/wm8904
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x20070000 size 0x10000
  scatter file: stm32wba65xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/USBX/App
    ../USBX/App/: ux_device_descriptors.c app_usbx_device.c app_usbx.c ux_device_audio.c ux_device_audio_play.c ux_device_audio_record.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/wm8904/: wm8904.c wm8904_reg.c
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery.c stm32wba65i_discovery_audio.c stm32wba65i_discovery_bus.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_pcd.c stm32wbaxx_hal_pcd_ex.c stm32wbaxx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/USBX/UX Device Controllers
    ../../../../../../Middlewares/ST/usbx/common/usbx_stm32_device_controllers/: ux_dcd_stm32_callback.c ux_dcd_stm32_endpoint_create.c ux_dcd_stm32_endpoint_destroy.c ux_dcd_stm32_endpoint_reset.c ux_dcd_stm32_endpoint_stall.c ux_dcd_stm32_endpoint_status.c ux_dcd_stm32_frame_number_get.c ux_dcd_stm32_function.c ux_dcd_stm32_initialize.c ux_dcd_stm32_initialize_complete.c ux_dcd_stm32_interrupt_handler.c ux_dcd_stm32_transfer_abort.c ux_dcd_stm32_transfer_run.c ux_dcd_stm32_uninitialize.c
  group Middlewares/USBX/Core System
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_system_tasks_run.c ux_utility_debug_callback_register.c ux_utility_debug_log.c ux_utility_delay_ms.c ux_utility_descriptor_pack.c ux_utility_descriptor_parse.c ux_utility_error_callback_register.c ux_utility_long_get.c ux_utility_long_get_big_endian.c ux_utility_long_put.c ux_utility_long_put_big_endian.c ux_utility_memory_allocate.c ux_utility_memory_allocate_add_safe.c ux_utility_memory_allocate_mulc_safe.c ux_utility_memory_allocate_mulv_safe.c ux_utility_memory_compare.c ux_utility_memory_copy.c ux_utility_memory_free.c ux_utility_memory_byte_pool_create.c ux_utility_memory_byte_pool_search.c ux_utility_memory_set.c ux_utility_physical_address.c ux_utility_set_interrupt_handler.c ux_utility_short_get.c ux_utility_short_get_big_endian.c ux_utility_short_put.c ux_utility_short_put_big_endian.c ux_utility_string_length_check.c ux_utility_string_length_get.c ux_utility_string_to_unicode.c ux_utility_unicode_to_string.c ux_utility_virtual_address.c ux_system_error_handler.c ux_system_initialize.c ux_system_uninitialize.c
  group Middlewares/USBX/UX Device Class AUDIO RECORDING
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_transmission_start.c ux_device_class_audio_write_frame_commit.c ux_device_class_audio_write_frame_get.c ux_device_class_audio_write_task_function.c
  group Middlewares/USBX/UX Device CoreStack
    ../../../../../../Middlewares/ST/usbx/common/core/src/: ux_device_stack_alternate_setting_get.c ux_device_stack_alternate_setting_set.c ux_device_stack_class_register.c ux_device_stack_class_unregister.c ux_device_stack_clear_feature.c ux_device_stack_configuration_get.c ux_device_stack_configuration_set.c ux_device_stack_control_request_process.c ux_device_stack_descriptor_send.c ux_device_stack_disconnect.c ux_device_stack_endpoint_stall.c ux_device_stack_get_status.c ux_device_stack_host_wakeup.c ux_device_stack_initialize.c ux_device_stack_interface_delete.c ux_device_stack_interface_get.c ux_device_stack_interface_set.c ux_device_stack_interface_start.c ux_device_stack_microsoft_extension_register.c ux_device_stack_set_feature.c ux_device_stack_transfer_abort.c ux_device_stack_transfer_all_request_abort.c ux_device_stack_transfer_request.c ux_device_stack_uninitialize.c ux_device_stack_tasks_run.c ux_device_stack_transfer_run.c
  group Middlewares/USBX/UX Device Class AUDIO
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_activate.c ux_device_class_audio_change.c ux_device_class_audio_control_request.c ux_device_class_audio_deactivate.c ux_device_class_audio_entry.c ux_device_class_audio_frame_write.c ux_device_class_audio_initialize.c ux_device_class_audio_ioctl.c ux_device_class_audio_sample_read8.c ux_device_class_audio_sample_read16.c ux_device_class_audio_sample_read24.c ux_device_class_audio_sample_read32.c ux_device_class_audio_stream_get.c ux_device_class_audio_unitialize.c ux_device_class_audio10_control_process.c ux_device_class_audio20_control_process.c ux_device_class_audio_feedback_get.c ux_device_class_audio_feedback_set.c ux_device_class_audio_interrupt_send.c ux_device_class_audio_speed_get.c ux_device_class_audio_tasks_run.c ux_device_class_audio_read_task_function.c ux_device_class_audio_interrupt_task_function.c ux_device_class_audio_feedback_task_function.c
  group Middlewares/USBX/UX Device Class AUDIO PLAYBACK
    ../../../../../../Middlewares/ST/usbx/common/usbx_device_classes/src/: ux_device_class_audio_read_frame_free.c ux_device_class_audio_read_frame_get.c ux_device_class_audio_reception_start.c
software components: CMSIS:CORE 5.6.0
