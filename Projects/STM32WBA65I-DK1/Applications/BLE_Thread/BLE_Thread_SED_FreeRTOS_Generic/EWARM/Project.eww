<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_Thread_SED_FreeRTOS_Generic.ewp</path>
  </project>
  <batchBuild />
</workspace>
