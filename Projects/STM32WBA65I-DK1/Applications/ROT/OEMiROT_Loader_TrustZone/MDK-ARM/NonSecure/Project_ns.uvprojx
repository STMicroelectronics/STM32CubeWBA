# Keil uVision project Project_ns.uvprojx, settings and files
target STM32WBA65I-DK1_OEMiROT_Loader_TrustZone_NS (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.4.0
  cpu: CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  AfterMake: ..\postbuild.bat "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA65xx,USE_HAL_DRIVER,LOCAL_LOADER_CONFIG
  c include: ../../NonSecure/Inc;../../Secure_nsclib;..\..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include;..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc;..\..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo;..\..\..\..\..\..\..\Drivers\BSP\STM32WBA55G-DK1;..\..\..\..\..\..\..\Drivers\BSP\STM32WBA65I-DK1;..\..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\..\Drivers\BSP\Components\m95p32;../../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\stm32wbaxx_flash_ns.sct
  link misc: --predefine=-DSTM32WBA65xx
--predefine=-I..\..\Secure_nsclib
../../Secure_nsclib/secure_nsclib.o
  group Doc
    ../../: README.md
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx.c
  group Application/User
    ../../NonSecure/Src/: low_level_flash.c low_level_device.c com.c common.c main.c fw_update_app.c startup_stm32wbaxx.c low_level_spi_device.c low_level_spi_flash.c ymodem.c tick.c
  group Drivers/BSP
    ../../../../../../../Drivers/BSP/Components/m95p32/: m95p32.c
    ../../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery_bus.c stm32wba65i_discovery_eeprom.c
