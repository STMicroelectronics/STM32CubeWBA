# IAR project Project_ns.ewp, settings and files
configuration STM32WBA65I-DK1_OEMiROT_Loader_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32WBA65xx; USE_HAL_DRIVER; LOCAL_LOADER_CONFIG
  ICCARM.CCIncludePath2: ..\..\Secure_nsclib; ..\..\NonSecure\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include\Templates; ..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver; ..\..\..\..\..\..\..\Drivers\BSP\STM32WBA55G-DK1; ..\..\..\..\..\..\..\Drivers\BSP\Components\m95p32; ..\..\..\..\..\..\..\Drivers\BSP\STM32WBA65I-DK1
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32WBA65xx"
  postbuild: cmd /C "cmd /C ..\postbuild.bat "nonsecure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ../../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_flash.c low_level_spi_device.c low_level_spi_flash.c main.c startup_stm32wbaxx.c tick.c ymodem.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/m95p32/: m95p32.c
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery_bus.c stm32wba65i_discovery_eeprom.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
