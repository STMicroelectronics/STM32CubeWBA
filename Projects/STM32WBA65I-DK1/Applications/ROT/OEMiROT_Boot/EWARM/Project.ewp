# IAR project Project.ewp, settings and files
configuration STM32WBA65I-DK1_OEMiROT_Boot (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32WBA65xx; USE_HAL_DRIVER; NDEBUG; MCUBOOT_TARGET_CONFIG=<flash_layout.h>; MBEDTLS_CONFIG_FILE=<mbedtls_config.h>; MCUBOOT_DOUBLE_SIGN_VERIF; FLOW_CONTROL; BL2; __INITIAL_SP=ARM_LIB_STACK$$Limit; __STACK_LIMIT=ARM_LIB_STACK$$Base; DEFAULT_UART_BAUDRATE=115200; OEMIROT_DEV_MODE; BOOT_MAX_ALIGN=16
  ICCARM.IExtraOptions: -DNO_TYPEOF
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\Drivers\BSP\STM32WBA55G-DK1; ..\..\..\..\..\..\Drivers\BSP\STM32WBA65I-DK1; ..\..\..\..\..\..\Drivers\BSP\Components\m95p32; ..\..\..\..\..\..\Drivers\CMSIS\Core\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\include\psa; ..\..\..\..\..\..\Middlewares\Third_Party\mbedtls\library; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\common; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\bl2\ext\mcuboot\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\boot\bootutil\src; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\tinycrypt\lib\include; ..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\ext\hal\Inc; ..\..\..\..\..\..\Middlewares\ST\mbedtls_alt\interfaces\patterns
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../Binary/OEMiROT_Boot.bin
  ILINK.IlinkOutputFile: STM32WBA65I-DK1.out
  ILINK.IlinkIcfFile: bl2.icf.i
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../Src/: bl2_nv_services.c boot_hal.c keys_map.c low_level_com.c low_level_device.c low_level_flash.c low_level_rng.c low_level_security.c low_level_spi_device.c low_level_spi_flash.c mpu_armv8m_drv.c startup_stm32wbaxx.c stm32wbaxx_hal_msp.c tick.c
  group Doc
    ../: README.md
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/m95p32/: m95p32.c
  group Drivers/BSP/STM32WBA65I-DK1
    ../../../../../../Drivers/BSP/STM32WBA65I-DK1/: stm32wba65i_discovery_bus.c stm32wba65i_discovery_eeprom.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Middlewares/mbedtls
    ../../../../../../Middlewares/Third_Party/mbedtls/library/: aes.c asn1parse.c bignum.c bignum_core.c cipher.c constant_time.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c hkdf.c hmac_drbg.c md.c memory_buffer_alloc.c platform.c platform_util.c sha256.c
  group Middlewares/mbedtls_alt
    ../../../../../../Middlewares/ST/mbedtls_alt/interfaces/patterns/: sha256_alt.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: boot_record.c bootutil_misc.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c shared_data.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
