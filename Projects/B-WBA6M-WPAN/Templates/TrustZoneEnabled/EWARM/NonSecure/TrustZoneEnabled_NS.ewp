# IAR project TrustZoneEnabled_NS.ewp, settings and files
configuration TrustZoneEnabled_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA6MOI ST STM32WBA6MOI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA6Mxx
  ICCARM.CCIncludePath2: ../../NonSecure/Inc; ../../Secure_nsclib; ../../../../../../Drivers/BSP/B-WBA6M-WPAN; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneEnabled_NS.hex
  ILINK.IlinkOutputFile: TrustZoneEnabled_NS.out
  ILINK.IlinkIcfFile: stm32wba6mxx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32wba6mxx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/B-WBA6M-WPAN
    ../../../../../../Drivers/BSP/B-WBA6M-WPAN/: b_wba6m_wpan.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx_ns.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c
