<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Sequencer_gpio_toggle.ewp</path>
  </project>
  <batchBuild />
</workspace>
