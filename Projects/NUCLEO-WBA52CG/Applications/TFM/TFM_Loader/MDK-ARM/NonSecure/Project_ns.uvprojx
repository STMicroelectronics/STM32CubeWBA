# Keil uVision project Project_ns.uvprojx, settings and files
target NUCLEO-WBA52CG_TFM_Loader_NS (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.0.4
  cpu: CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: ..\postbuild.bat  "nonsecure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA52xx,USE_HAL_DRIVER,LOCAL_LOADER_CONFIG,BL2
  c include: ../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../Linker;../../Secure_nsclib;../../NonSecure/Inc;../../../../../../../Middlewares/Third_Party/trustedfirmware/platform/ext/driver
  library: MicroLIB
  scatter file: .\stm32wba52xx_flash_ns.sct
  link misc: --predefine=-DBL2
--predefine=-DSTM32WBA52xx
--predefine=-I../../../Linker
../../Secure_nsclib/secure_nsclib.o
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx.c
  group Application/User
    ../../NonSecure/Src/: low_level_flash.c tick.c com.c common.c fw_update_app.c low_level_device.c main.c ymodem.c startup_stm32wbaxx.c
software components: CMSIS:CORE 4.3.0
