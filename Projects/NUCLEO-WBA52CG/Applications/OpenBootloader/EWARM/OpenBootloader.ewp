# IAR project OpenBootloader.ewp, settings and files
configuration NUCLEO-WBA52CG (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA52CG ST STM32WBA52CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32WBA52xx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\OpenBootloader\App; ..\OpenBootloader\Target; ..\Core\Inc; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Core; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\I2C; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\SPI; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\USART; ..\..\..\..\..\Middlewares\ST\OpenBootloader\Modules\Mem; ..\..\..\..\..\Drivers\CMSIS\Core; ..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\Drivers\CMSIS\Core\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OpenBootloader.hex
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wba52xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Core
    ../Core/Src/: main.c stm32wbaxx_it.c
  group Application/EWARM
    ./: startup_stm32wba52xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c flash_interface.c i2c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c spi_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_i2c.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_spi.c stm32wbaxx_ll_usart.c
  group Middlewares/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/Modules/SPI
    ../../../../../Middlewares/ST/OpenBootloader/Modules/SPI/: openbl_spi_cmd.c
  group Middlewares/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
