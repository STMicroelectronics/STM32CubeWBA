# Keil uVision project BLE_ApplicationInstallManager.uvprojx, settings and files
target BLE_ApplicationInstallManager (6180000::V6.18::ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x20010000-0x2001FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BLE_ApplicationInstallManager +hex
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,PHY_2_10_a,PHY_40nm_2_30_a_A1,BLE,USE_HAL_DRIVER,STM32WBA52xx
  c include: ../Core/Inc;../System/Interfaces;../System/Modules;../System/Modules/baes;../System/Modules/MemoryManager;../System/Modules/Nvm;../System/Modules/Flash;../System/Config;../System/Config/Flash;../STM32_WPAN/App;../STM32_WPAN/Target;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/phy;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/tim_serv;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_basic;../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/phy/_40nm_reg_files;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto;../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../../../../../Middlewares/ST/STM32_WPAN/ble/system/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../System/Modules/RTDebug;../System/Config/Debug_GPIO;../System/Config/LowPower
  memory RVCT4: ROM 0x8000000 size 0xfc000
  memory RVCT5: ROM 0x80fc000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: stm32wba52xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba52xx.s
  group Application/User/Core
    ../Core/Src/: main.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c
  group Doc
    ../: README.md
software components: CMSIS:CORE 4.3.0
