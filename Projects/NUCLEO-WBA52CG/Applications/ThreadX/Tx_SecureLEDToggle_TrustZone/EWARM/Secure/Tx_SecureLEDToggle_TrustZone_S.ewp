# IAR project Tx_SecureLEDToggle_TrustZone_S.ewp, settings and files
configuration Tx_SecureLEDToggle_TrustZone_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA52CG ST STM32WBA52CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA52xx
  ICCARM.CCIncludePath2: ../../Secure/Inc; ../../Secure_nsclib; ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Tx_SecureLEDToggle_TrustZone_S.hex
  ILINK.IlinkOutputFile: Tx_SecureLEDToggle_TrustZone_S.out
  ILINK.IlinkIcfFile: stm32wba52xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32wba52xx.s
  group Application/User/Secure
    ../../Secure/Src/: main.c secure_nsc.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32wbaxx_s.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c
  group Middlewares/ThreadX/Core
    ../../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_thread_secure_stack.c
