# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-WBA52CG_SBSFU_Boot (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.0.4
  cpu: IROM(0x08000000-0x8007FFF) IRAM(0x20000000-0x20002FFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  BeforeMake: $J\..\bin\armclang --target=arm-arm-none-eabi -march=armv8-m.main -E -P -xc -DSTM32WBA52xx -DBL2 -I..\..\Linker -I..\Inc -I..\..\..\..\..\..\Drivers\CMSIS\Include -I..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include -I..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc ..\Src\image_macros_to_preprocess_bl2.c -o image_macros_preprocessed_bl2.c
  AfterMake: fromelf #L --bin --output=$L@L.bin
  AfterMake: postbuild.bat
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA52xx,USE_HAL_DRIVER,NDEBUG,MCUBOOT_TARGET_CONFIG=<flash_layout.h>,MBEDTLS_CONFIG_FILE=<config-boot.h>,MCUBOOT_DOUBLE_SIGN_VERIF,FLOW_CONTROL,BL2,DEFAULT_UART_BAUDRATE=115200,TFM_DEV_MODE,BOOT_MAX_ALIGN=16
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../Drivers/BSP/Components/Common;../../Linker;../../../../../../Middlewares/Third_Party/mbed-crypto/include;../../../../../../Middlewares/Third_Party/mbed-crypto/library;../../../../../../Middlewares/Third_Party/mcuboot;../../../../../../Middlewares/Third_Party/mcuboot/platform/include;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common;../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver;../../../../../../Middlewares/Third_Party/mcuboot/bl2/include;../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot;../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/include;../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src;../../../../../../Middlewares/Third_Party/mcuboot/ext/tinycrypt/lib/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\stm32wbaxx_bl2.sct
  link misc: --predefine=-I../../Linker
--predefine=-DBL2
--predefine=-DSTM32WBA52xx
--keep=keys_map.o(.bootutil_enc_key)
--predefine=-DTFM_PSA_API
--entry=Reset_Handler
  group Application/User
    ../Src/: aes_alt.c bl2_nv_services.c boot_hal.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c keys.c keys_map.c low_level_com.c low_level_device.c low_level_flash.c low_level_rng.c low_level_security.c mpu_armv8m_drv.c rsa_alt.c sha256_alt.c stm32wbaxx_hal_msp.c tick.c startup_stm32wbaxx.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Middlewares/mbed-crypto
    ../../../../../../Middlewares/Third_Party/mbed-crypto/library/: aes.c asn1parse.c bignum.c constant_time.c ctr_drbg.c ecdh.c ecdsa.c ecp.c ecp_curves.c entropy.c hkdf.c md.c memory_buffer_alloc.c platform.c platform_util.c rsa.c rsa_internal.c sha256.c cipher_wrap.c asn1write.c
  group Middlewares/mcuboot
    ../../../../../../Middlewares/Third_Party/mcuboot/boot/bootutil/src/: bootutil_misc.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ec.c image_ec256.c image_rsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_scratch.c tlv.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/ext/mcuboot/: bl2_main.c flash_map_extended.c flash_map_legacy.c
    ../../../../../../Middlewares/Third_Party/mcuboot/bl2/src/: flash_map.c security_cnt.c
    ../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/common/: uart_stdout.c
software components: CMSIS:CORE 5.3.0
