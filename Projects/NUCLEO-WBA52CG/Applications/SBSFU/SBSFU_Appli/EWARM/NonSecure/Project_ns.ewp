# IAR project Project_ns.ewp, settings and files
configuration NUCLEO-WBA52CG_SBSFU_Appli_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA52CG ST STM32WBA52CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 0
  ICCARM.CCDefines: STM32WBA52xx; USE_HAL_DRIVER; BL2
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\Linker; ..\..\Secure_nsclib; ..\..\NonSecure\Inc; ..\..\..\..\..\..\..\Middlewares\Third_Party\trustedfirmware\platform\ext\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  prebuild: prebuild_ns.cmd "$PROJ_DIR$" "STM32WBA52xx"
  postbuild: cmd /C "cmd /C ..\postbuild.bat "$PROJ_DIR$"  "1.0.0" "nonsecure""
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wba52xx_flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ..\Secure\NUCLEO-WBA52CG_S\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx.c
  group Application/User
    ../../NonSecure/Src/: low_level_flash.c com.c common.c fw_update_app.c stm32wbaxx_it.c low_level_device.c main.c ns_data.c test_protections.c ymodem.c mpu_armv8m_drv.c startup_stm32wbaxx.c
  group Doc
    ../../: README.md
