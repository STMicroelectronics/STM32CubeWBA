# Keil uVision project Project_s.uvprojx, settings and files
target NUCLEO-WBA52CG_SBSFU_Appli_S (6130001::V6.13.1::.\ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.0.4
  cpu: IROM(0x08000000-0x8007FFF) IRAM(0x20000000-0x20002FFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project
  AfterMake: fromelf #L --bincombined --output=$L@L.bin
  AfterMake: ..\postbuild.bat . "1.0.0" "secure"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA52xx,USE_HAL_DRIVER,BL2
  c include: ../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../Linker;../../Secure/Inc;../../Secure_nsclib;../../../../../../../Middlewares/Third_Party/mcuboot/platform/ext/driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\stm32wba52xx_flash_s.sct
  link misc: --predefine=-I../../../Linker
--predefine=-DBL2
--predefine=-DSTM32WBA52xx
--import_cmse_lib_out=.\..\..\Secure_nsclib\secure_nsclib.o
  group Application/User
    ../../Secure/Src/: low_level_device.c low_level_flash.c main.c secure_nsc.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c startup_stm32wbaxx.c
  group Drivers/CMSIS
    ../../Secure/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c
software components: CMSIS:CORE 4.3.0
