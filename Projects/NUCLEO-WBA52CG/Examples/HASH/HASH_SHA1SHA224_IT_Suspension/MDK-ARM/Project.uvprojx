# Keil uVision project Project.uvprojx, settings and files
target HASH_SHA1SHA224_IT_Suspension (6180000::V6.18::ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.3.0
  cpu: IROM(0x08000000-0x80FFFFF) IRAM(0x20000000-0x2001FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA52xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../Drivers/BSP/Components/Common
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32wba52xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Doc
    ../: readme.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Example/MDK-ARM
    ./: startup_stm32wba52xx.s
  group Example/User
    ../Src/: main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
software components: CMSIS:CORE 4.3.0
