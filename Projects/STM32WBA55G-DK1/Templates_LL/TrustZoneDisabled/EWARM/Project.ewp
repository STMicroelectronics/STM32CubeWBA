# IAR project Project.ewp, settings and files
configuration STM32WBA55G-DK1_Templates_LL (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32WBA55xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: ..\Inc; ..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_adc.c stm32wbaxx_ll_crc.c stm32wbaxx_ll_dma.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_i2c.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_lptim.c stm32wbaxx_ll_lpuart.c stm32wbaxx_ll_pka.c stm32wbaxx_ll_pwr.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_rng.c stm32wbaxx_ll_rtc.c stm32wbaxx_ll_spi.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_usart.c stm32wbaxx_ll_utils.c
  group Example/EWARM
    ./: startup_stm32wba55xx.s
  group Example/User
    ../Src/: main.c stm32wbaxx_it.c
