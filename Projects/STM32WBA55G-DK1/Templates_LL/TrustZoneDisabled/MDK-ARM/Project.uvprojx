# Keil uVision project Project.uvprojx, settings and files
target STM32WBA55G-DK1_Templates_LL (6160000::V6.16::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x30000000,0x020000) IROM(0x08000000,0x00100000) IROM2(0x0C000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA55xx,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: stm32wba55xx_flash.sct
  link misc: --diag_suppress=L6329
--diag_suppress L6314W
--diag_suppress 1296
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_adc.c stm32wbaxx_ll_crc.c stm32wbaxx_ll_dma.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_i2c.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_lptim.c stm32wbaxx_ll_lpuart.c stm32wbaxx_ll_pka.c stm32wbaxx_ll_pwr.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_rng.c stm32wbaxx_ll_rtc.c stm32wbaxx_ll_spi.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_usart.c stm32wbaxx_ll_utils.c
  group Example/MDK-ARM
    ./: startup_stm32wba55xx.s
  group Example/User
    ../Src/: main.c stm32wbaxx_it.c
