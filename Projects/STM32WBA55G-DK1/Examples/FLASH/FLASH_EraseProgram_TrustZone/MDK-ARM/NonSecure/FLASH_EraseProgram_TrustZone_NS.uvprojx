# Keil uVision project FLASH_EraseProgram_TrustZone_NS.uvprojx, settings and files
target FLASH_EraseProgram_TrustZone_NS (6180000::V6.18::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.1.0.1
  cpu: IRAM(0x20010000-0x2001FFFF) IROM(0x08080000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: FLASH_EraseProgram_TrustZone_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA55xx
  c include: ../../NonSecure/Inc;../../Secure_nsclib;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../../Drivers/BSP/STM32WBA55G-DK1
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x10000
  scatter file: stm32wba55xx_flash_ns.sct
  link misc: ../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba55xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBA55G-DK1
    ../../../../../../../Drivers/BSP/STM32WBA55G-DK1/: stm32wba55g_discovery.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_hsem.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx_ns.c
software components: CMSIS:CORE 4.3.0
