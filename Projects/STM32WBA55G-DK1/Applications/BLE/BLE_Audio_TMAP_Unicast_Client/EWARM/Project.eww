<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_Audio_TMAP_Unicast_Client.ewp</path>
  </project>
  <batchBuild />
</workspace>
