# IAR project BLE_Audio_TMAP_Unicast_Client.ewp, settings and files
configuration BLE_Audio_TMAP_Unicast_Client (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CCP_SUPPORT; MCP_SUPPORT; VCP_SUPPORT; USE_FULL_LL_DRIVER; BLE; USE_HAL_DRIVER; STM32WBA55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../System/Interfaces; ../System/Modules; ../System/Modules/baes; ../System/Modules/Flash; ../System/Modules/MemoryManager; ../System/Modules/Nvm; ../System/Modules/RTDebug; ../System/Modules/RFControl; ../System/Modules/SerialCmdInterpreter; ../System/Config/Log; ../System/Config/LowPower; ../System/Config/Debug_GPIO; ../System/Config/Flash; ../System/Config/CRC_Ctrl; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/tim_serv; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_full; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WBA55G-DK1; ../../../../../../Drivers/BSP/Components/Common; ../../../../../../Drivers/BSP/Components/cs42l51; ../../../../../../Drivers/BSP/Components/ssd1315; ../../../../../../Middlewares/ST/STM32_WPAN/ble/audio/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/lc3/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/codec_manager/Inc; ../STM32_WPAN/App/AudioUseCases; ../STM32_WPAN/App/AudioUseCases/tmap; ../Core/Src/lcd; ../../../../../../Utilities/LCD
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_Audio_TMAP_Unicast_Client.bin
  ILINK.IlinkOutputFile: BLE_Audio_TMAP_Unicast_Client.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/Src/: app_entry.c image.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c app_menu.c app_menu_cfg.c tmap_app.c
  group Application/User/STM32_WPAN/App/AudioUseCases
    ../STM32_WPAN/App/AudioUseCases/tmap/: tmap.c tmap_alloc.c tmap_db.c tmas.c
    ../STM32_WPAN/App/AudioUseCases/: usecase_dev_mgmt.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: ble_audio_if.c ble_audio_plat.c ble_codec.c bleplat.c bpka.c codec_if.c host_stack_if.c linklayer_plat.c ll_sys_if.c power_table.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/Log
    ../System/Config/Log/: log_module.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: hw_aes.c hw_otp.c hw_pka.c hw_rng.c pka_p256.c stm32_lpm_if.c timer_if.c usart_if.c
  group Application/User/System/Modules
    ../System/Modules/: app_sys.c ble_timer.c crc_ctrl.c otp.c scm.c stm_list.c stm_queue.c
  group Application/User/System/Modules/baes
    ../System/Modules/baes/: baes_cmac.c baes_ecb.c
  group Application/User/System/Modules/Flash
    ../System/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Application/User/System/Modules/MemoryManager
    ../System/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Application/User/System/Modules/Nvm
    ../System/Modules/Nvm/: nvm_emul.c
  group Application/User/System/Modules/RFControl
    ../System/Modules/RFControl/: rf_antenna_switch.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Application/User/System/Modules/SerialCmdInterpreter
    ../System/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Application/User/System/Startup
    ../System/Startup/: stm32wbaxx_ResetHandler.S
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32WBA55G-DK1/: stm32wba55g_discovery.c stm32wba55g_discovery_audio.c stm32wba55g_discovery_bus.c stm32wba55g_discovery_lcd.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/Components
    ../../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/audio/lib/: ble_audio.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Full_lib.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/STM32_WPAN/codec
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/codec_manager/Lib/: codec_mngr.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/lc3/Lib/: LC3.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/LCD/: stm32_lcd.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
