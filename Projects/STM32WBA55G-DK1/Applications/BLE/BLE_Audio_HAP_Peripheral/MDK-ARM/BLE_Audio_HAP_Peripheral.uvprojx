# Keil uVision project BLE_Audio_HAP_Peripheral.uvprojx, settings and files
target BLE_Audio_HAP_Peripheral (6190000::V6.19::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x30000000,0x020000) IROM(0x08000000,0x00100000) IROM2(0x0C000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: BLE_Audio_HAP_Peripheral +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,BLE_LL,USE_HAL_DRIVER,STM32WBA55xx
  c misc: -fshort-enums
  c include: ../Core/Inc;../System/Interfaces;../System/Modules;../System/Config;../System/Config/Log;../System/Config/LowPower;../System/Config/Debug_GPIO;../System/Config/Flash;../System/Config/CRC_Ctrl;../STM32_WPAN/App;../STM32_WPAN/Target;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/trace/adv_trace;../../../../../../Projects/Common/WPAN/Interfaces;../../../../../../Projects/Common/WPAN/Modules;../../../../../../Projects/Common/WPAN/Modules/BasicAES;../../../../../../Projects/Common/WPAN/Modules/Flash;../../../../../../Projects/Common/WPAN/Modules/MemoryManager;../../../../../../Projects/Common/WPAN/Modules/RTDebug;../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter;../../../../../../Projects/Common/WPAN/Modules/Log;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/tim_serv;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_full;../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto;../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WBA55G-DK1;../../../../../../Drivers/BSP/Components/Common;../../../../../../Drivers/BSP/Components/cs42l51;../../../../../../Drivers/BSP/Components/ssd1315;../../../../../../Middlewares/ST/STM32_WPAN/ble/audio/Inc;../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/lc3/Inc;../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/codec_manager/Inc;../STM32_WPAN/App/AudioUseCases;../STM32_WPAN/App/AudioUseCases/hap;../Core/Src/lcd;../../../../../../Utilities/LCD
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: stm32wba55xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/Src/: image.c main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c ll_sys_if.c host_stack_if.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_menu.c app_menu_cfg.c hap_app.c app_ble.c
  group Application/User/STM32_WPAN/App/AudioUseCases
    ../STM32_WPAN/App/AudioUseCases/: usecase_dev_mgmt.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../Common/WPAN/Interfaces/: app_bsp.c
    ../../../../../../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../../Projects/Common/WPAN/Modules/: app_sys.c crc_ctrl.c otp.c pka_ctrl.c scm.c stm_list.c stm_queue.c wpan_utils.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../../Projects/Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Modules/Log
    ../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Startup
    ../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_MDK-ARM.s
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32WBA55G-DK1/: stm32wba55g_discovery.c stm32wba55g_discovery_audio.c stm32wba55g_discovery_bus.c stm32wba55g_discovery_lcd.c
  group Drivers/Components
    ../../../../../../Drivers/BSP/Components/cs42l51/: cs42l51.c cs42l51_reg.c
    ../../../../../../Drivers/BSP/Components/ssd1315/: ssd1315.c ssd1315_reg.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_pka.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_utils.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/STM32_WPAN/codec
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/codec_manager/Lib/: codec_mngr.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/codec/lc3/Lib/: LC3.a
  group Utilities
    ../../../../../../Utilities/LCD/: stm32_lcd.c
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Common/WPAN/Interface/Audio
    ../../../../../../Projects/Common/WPAN/Interfaces/Audio/: ble_audio_if.c ble_audio_plat.c
  group Common/WPAN/Interface/Codec
    ../../../../../../Projects/Common/WPAN/Interfaces/Codec/: codec_if.c ble_codec.c
  group Application/User/STM32_WPAN/App/AudioUseCases/hap
    ../STM32_WPAN/App/AudioUseCases/hap/: hap.c hap_alloc.c hap_db.c hap_ha.c hap_harc.c hap_iac.c has.c ias.c
  group Doc
    ../: README.md
  group Middlewares/STM32_WPAN
    ./: 
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/audio/lib/: ble_audio.a
  group Middlewares/STM32_WPAN/LinkLayer
    ./: 
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Full_V3_0.a
  group Middlewares/STM32_WPAN/BLE
    ./: 
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
software components: CMSIS:CORE 5.6.0
