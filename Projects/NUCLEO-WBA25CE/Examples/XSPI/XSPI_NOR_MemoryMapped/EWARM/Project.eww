<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\XSPI_NOR_MemoryMapped.ewp</path>
  </project>
  <batchBuild />
</workspace>
