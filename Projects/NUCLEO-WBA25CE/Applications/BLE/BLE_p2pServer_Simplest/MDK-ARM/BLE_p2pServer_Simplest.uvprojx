# Keil uVision project BLE_p2pServer_Simplest.uvprojx, settings and files
target BLE_p2pServer_Simplest (6190000::V6.19::ARMCLANG)
  device: STM32WBA25CEUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.6.0-B01
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BLE_p2pServer_Simplest +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,BLE_LL,BLE_STACK_PERIPHERAL_ONLY,PHY_40nm_6_00_a,USE_HAL_DRIVER,STM32WBA25xx
  c misc: -fshort-enums
  c include: ../Core/Inc;../System/Modules;../STM32_WPAN/App;../STM32_WPAN/Target;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_peripheral_only;../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc;../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include;../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto;../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: stm32wba25xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba25xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: skel_ble.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c ll_sys_if.c host_stack_if.c
  group Application/User/System/Modules
    ../System/Modules/: stm_list.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_utils.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_pka.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: WBA2_LinkLayer_BLE_Peripheral_Only_lib.a
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_po.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
software components: CMSIS:CORE 5.6.0
