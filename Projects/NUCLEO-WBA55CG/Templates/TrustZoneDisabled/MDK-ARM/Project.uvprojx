# Keil uVision project Project.uvprojx, settings and files
target NUCLEO-WBA55CG_Templates_Legacy (6160000::V6.16::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x30000000,0x020000) IROM(0x08000000,0x00100000) IROM2(0x0C000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA55xx,USE_HAL_DRIVER
  c include: ../Inc;../../../../../Drivers/CMSIS/Include;../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../Drivers/BSP/Components/Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: stm32wba55xx_flash.sct
  link misc: --diag_suppress=L6329
--diag_suppress L6314W
--diag_suppress 1296
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_irda.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_smartcard.c stm32wbaxx_hal_smartcard_ex.c stm32wbaxx_hal_smbus.c stm32wbaxx_hal_smbus_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_tsc.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_hal_wwdg.c
  group Example/MDK-ARM
    ./: startup_stm32wba55xx.s
  group Example/User
    ../Src/: main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
