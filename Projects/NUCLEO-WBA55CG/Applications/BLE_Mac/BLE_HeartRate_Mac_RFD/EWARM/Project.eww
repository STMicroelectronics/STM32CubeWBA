<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_HeartRate_Mac_RFD.ewp</path>
  </project>
  <batchBuild />
</workspace>
