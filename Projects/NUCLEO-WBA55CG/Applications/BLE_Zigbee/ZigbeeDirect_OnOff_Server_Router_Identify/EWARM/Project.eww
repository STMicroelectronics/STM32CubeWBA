<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ZigbeeDirect_OnOff_Server_Router_Identify.ewp</path>
    </project>
    <batchBuild />
</workspace>
