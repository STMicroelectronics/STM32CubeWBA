# IAR project ZigbeeDirect_OnOff.ewp, settings and files
configuration ZigbeeDirect_OnOff (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; BLE; MAC; MAC_LAYER; USE_HAL_DRIVER; STM32WBA55xx; USE_FULL_ASSERT; STM32; STM32WBA; STM32WBA55xx; USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; PHY_2_10_a; PHY_40nm_2_30_a_A1; LOGGER_ENABLE=0; LOGUARTENABLED; MAC; MAC_LAYER; OS_BAREMETAL; BYTE_ORDER=1234; ZB_UPTIME_MAX=0x8000000; CONFIG_ZB_INIT_CUSTOM=1; CONFIG_ZB_LOG_ALLOWED_MASK=0x201F; CONFIG_ZB_BDB_DEFAULT_JOIN_SCAN_TYPE=MCP_SCAN_ACTIVE; CONFIG_ZB_ZCL_TOUCHLINK=1; CONFIG_ZB_GREENPOWER=1; CONFIG_ZB_DIAGNOSTICS=1; APPLICATION_USE_BAREMETAL; APPLICATION_USE_HW_AES; APPLICATION_USE_HW_RNG; LOGFMTu64="%llu"; BLE=1; CONFIG_ZB_ZIGBEE_DIRECT=1; CONFIG_ZB_ZDD=1
  ICCARM.CCIncludePath2: ../Core/Inc; ../System/Interfaces; ../System/Modules; ../System/Config/Log; ../System/Config/LowPower; ../System/Config/Debug_GPIO; ../System/Config/Flash; ../System/Config/CRC_Ctrl; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Projects/Common/WPAN/Interfaces; ../../../../../../Projects/Common/WPAN/Modules; ../../../../../../Projects/Common/WPAN/Modules/BasicAES; ../../../../../../Projects/Common/WPAN/Modules/Flash; ../../../../../../Projects/Common/WPAN/Modules/MemoryManager; ../../../../../../Projects/Common/WPAN/Modules/Nvm; ../../../../../../Projects/Common/WPAN/Modules/RTDebug; ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter; ../../../../../../Projects/Common/WPAN/Modules/Log; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/tim_serv; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/concurrent/ble_15_4; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters_zd/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/ble_interface; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zcl; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zcl/general; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zcl/key; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zcl/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zcl/security; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zcl/zd; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include_zd/zgp; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd/eclite\src\include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd/zd; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd/eclite/sha/include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd/port/mac; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd/port/stm32wba; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ZigbeeDirect_OnOff.hex
  ILINK.IlinkOutputFile: ZigbeeDirect_OnOff.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c app_bsp.c app_zigbee.c app_zigbee_debug_zd.c app_zigbee_endpoint.c dis.c dis_app.c tunneling.c tunneling_app.c zddsecurity.c zddsecurity_app.c zigbeedirectcomm.c zigbeedirectcomm_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c bpka.c host_stack_if.c linklayer_plat.c ll_sys_if.c mac_sys_if.c power_table.c zigbee_plat.c zigbee_sys_if.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_pka.c hw_pka_p256.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../Common/WPAN/Modules/: app_sys.c crc_ctrl.c otp.c scm.c stm_list.c stm_queue.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../Common/WPAN/Modules/BasicAES/: baes_ccm.c baes_cmac.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/Log
    ../../../../../Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/Nvm
    ../../../../../Common/WPAN/Modules/Nvm/: nvm_emul.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_adc.c stm32wbaxx_ll_dma.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_utils.c
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_basic.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Mac_lib.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Middlewares/STM32_WPAN/Mac_802_15_4
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/STM32_WPAN/Zigbee
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters_zd/: ZigBeeClusters.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack_zd/: ZigBeeProR23_ZDD.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
