# IAR project BLE_HeartRate_Zigbee.ewp, settings and files
configuration BLE_HeartRate_Zigbee (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; BLE; MAC; MAC_LAYER; USE_HAL_DRIVER; STM32WBA55xx; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../Core/Inc; ../System/Interfaces; ../System/Modules; ../System/Config/Log; ../System/Config/LowPower; ../System/Config/Debug_GPIO; ../System/Config/Flash; ../System/Config/ADC_Ctrl; ../System/Config/CRC_Ctrl; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Projects/Common/WPAN/Interfaces; ../../../../../../Projects/Common/WPAN/Modules; ../../../../../../Projects/Common/WPAN/Modules/BasicAES; ../../../../../../Projects/Common/WPAN/Modules/Flash; ../../../../../../Projects/Common/WPAN/Modules/MemoryManager; ../../../../../../Projects/Common/WPAN/Modules/Nvm; ../../../../../../Projects/Common/WPAN/Modules/RFControl; ../../../../../../Projects/Common/WPAN/Modules/RTDebug; ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter; ../../../../../../Projects/Common/WPAN/Modules/Log; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/tim_serv; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/concurrent/ble_15_4; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/general; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/key; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/security; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/zd; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zgp; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port/mac; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port/stm32wba; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo; ../Drivers/STM32U5xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_HeartRate_Zigbee.hex
  ILINK.IlinkOutputFile: BLE_HeartRate_Zigbee.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba55xx.s
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_bsp.c app_ble.c app_zigbee_endpoint.c app_zigbee.c hrs.c hrs_app.c dis.c dis_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c bpka.c ll_sys_if.c host_stack_if.c mac_sys_if.c zigbee_plat.c zigbee_sys_if.c
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/ADC_Ctrl
    ../System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_pka.c hw_pka_p256.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../../Projects/Common/WPAN/Modules/: adc_ctrl.c temp_measurement.c app_sys.c crc_ctrl.c otp.c scm.c stm_list.c stm_queue.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../../Projects/Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/Nvm
    ../../../../../../Projects/Common/WPAN/Modules/Nvm/: nvm_emul.c
  group Common/WPAN/Modules/RFControl
    ../../../../../../Projects/Common/WPAN/Modules/RFControl/: rf_antenna_switch.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Modules/Log
    ../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Startup
    ../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_utils.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_dma.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_adc.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Mac_lib.a
  group Middlewares/STM32_WPAN/Mac_802_15_4
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_basic.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/STM32_WPAN/Zigbee
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/: ZigBeeProR23_FFD.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/: ZigBeeClusters.a
