# Keil uVision project Project.uvprojx, settings and files
target Phy_Cli (6190000::V6.19::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.6.0-B01
  cpu: IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Phy_Cli +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA55xx,USE_FULL_ASSERT,USE_FULL_LL_DRIVER,LOGGER_ENABLE=0,OS_BAREMETAL,MAC,MAC_LAYER
  c misc: -fshort-enums
  c include: ../Core/Inc;../System/Interfaces;../System/Config;..\..\..\..\..\Common\WPAN\Modules;..\..\..\..\..\Common\WPAN\Interfaces;..\STM32_WPAN\App;..\..\..\..\..\Common\WPAN\Modules\RTDebug;../STM32_WPAN/Target;..\System\Interfaces;../System/Config/Debug_GPIO;../System/Config/LowPower;..\System\Config;..\System\Config\Log;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting;../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/tim_serv;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/thread;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\src\shrd_utils\inc;..\..\..\..\..\..\Middlewares\ST\STM32_WPAN
  memory RVCT4: ROM 0x8000000 size 0x100000
  scatter file: stm32wba55xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/System/Startup
    ../../../../../Common/WPAN/Startup/: stm32wbaxx_ResetHandler_MDK-ARM.s
  group Application/User/System/Modules
    ../../../../../Common/WPAN/Modules/: app_sys.c otp.c scm.c
    ../../../../../../Projects/Common/WPAN/Modules/: pka_ctrl.c
  group Application/User/System/Modules/RTDebug
    ../../../../../Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Application/User/System/Interfaces
    ../../../../../Common/WPAN/Interfaces/: hw_aes.c hw_rng.c timer_if.c
    ../System/Interfaces/: stm32_lpm_if.c usart_if.c
  group Application/User/System/Config/Log
    ../System/Config/Log/: log_module.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_cli_runner.c app_cli_runner_ex.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: power_table.c linklayer_plat.c ll_sys_if.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_802_15_4_V3_0.a
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 5.6.0
