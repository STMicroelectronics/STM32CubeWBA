# IAR project BLE_HeartRate_Thread.ewp, settings and files
configuration BLE_HeartRate_Thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; BLE; OPENTHREAD_FTD; OPENTHREAD_CONFIG_FILE=<stm32wba-openthread-ftd-config.h>; OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wba-openthread-ftd-config.h>; MAC; MAC_LAYER; USE_HAL_DRIVER; STM32WBA55xx; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: ../Core/Inc; ../System/Interfaces; ../System/Modules; ../System/Config/Log; ../System/Config/LowPower; ../System/Config/Debug_GPIO; ../System/Config/Flash; ../System/Config/ADC_Ctrl; ../System/Config/CRC_Ctrl; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Projects/Common/WPAN/Interfaces; ../../../../../../Projects/Common/WPAN/Modules; ../../../../../../Projects/Common/WPAN/Modules/BasicAES; ../../../../../../Projects/Common/WPAN/Modules/Flash; ../../../../../../Projects/Common/WPAN/Modules/MemoryManager; ../../../../../../Projects/Common/WPAN/Modules/RFControl; ../../../../../../Projects/Common/WPAN/Modules/RTDebug; ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter; ../../../../../../Projects/Common/WPAN/Modules/Log; ../../../../../../Utilities/misc; ../../../../../../Utilities/sequencer; ../../../../../../Utilities/tim_serv; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/concurrent/ble_thread; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto; ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/common; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/config; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/platform; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls; ../../../../../../Middlewares/Third_Party/mbedtls/include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/src/core/config; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/mbedtls; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/third_party/mbedtls/repo/include/psa; ../../../../../../Middlewares/Third_Party/mbedtls/include/mbedtls; ../Drivers/STM32U5xx_HAL_Driver/Inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_HeartRate_Thread.hex
  ILINK.IlinkOutputFile: BLE_HeartRate_Thread.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkExtraOptions: --log sections
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c app_bsp.c app_thread.c dis.c dis_app.c hrs.c hrs_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c bpka.c host_stack_if.c linklayer_plat.c ll_sys_if.c power_table.c
  group Application/User/System/Config/ADC_Ctrl
    ../System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_pka.c hw_pka_p256.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../Common/WPAN/Modules/: adc_ctrl.c app_sys.c crc_ctrl.c otp.c scm.c stm_list.c stm_queue.c temp_measurement.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../Common/WPAN/Modules/BasicAES/: baes_ccm.c baes_cmac.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/Log
    ../../../../../Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RFControl
    ../../../../../Common/WPAN/Modules/RFControl/: rf_antenna_switch.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_adc.c stm32wbaxx_ll_dma.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_utils.c
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_basic.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Thread_lib.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Middlewares/STM32_WPAN/Thread
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/platform/: alarm.c crypto_platform.c diag.c entropy_renamed.c flash.c logging_stm32wba.c misc.c spi-stubs.c system.c uart.c uart_rcp.c
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/openthread_lib/: stm32wba_mbedtls_ftd_lib.a stm32wba_ot_ftd_lib.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
