# Keil uVision project OpenBootloader.uvprojx, settings and files
target NUCLEO-WBA52CG (6180000::V6.18::ARMCLANG)
  device: STM32WBA52CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.0.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x30000000,0x020000) IROM(0x08000000,0x00100000) IROM2(0x0C000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32WBA52xx,USE_HAL_DRIVER,USE_FULL_LL_DRIVER
  c include: ../OpenBootloader/App;../OpenBootloader/Target;../Core/Inc;../../../../../Middlewares/ST/OpenBootloader/Core;../../../../../Middlewares/ST/OpenBootloader/Modules/I2C;../../../../../Middlewares/ST/OpenBootloader/Modules/SPI;../../../../../Middlewares/ST/OpenBootloader/Modules/USART;../../../../../Middlewares/ST/OpenBootloader/Modules/Mem;../../../../../Drivers/CMSIS/Core;../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../Drivers/CMSIS/Core/Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x30000000 size 0x20000
  scatter file: stm32wba52xx_flash.sct
  link misc: --diag_suppress=L6329
--diag_suppress L6314W
--diag_suppress 1296
  group Application/Core
    ../Core/Src/: main.c stm32wbaxx_it.c
  group Application/MDK-ARM
    ./: startup_stm32wba52xx.s
  group Application/OpenBootloader/App
    ../OpenBootloader/App/: app_openbootloader.c
  group Application/OpenBootloader/Target
    ../OpenBootloader/Target/: common_interface.c engibytes_interface.c flash_interface.c i2c_interface.c iwdg_interface.c optionbytes_interface.c otp_interface.c ram_interface.c spi_interface.c systemmemory_interface.c usart_interface.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_i2c.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_spi.c stm32wbaxx_ll_usart.c
  group Middlewares/Core
    ../../../../../Middlewares/ST/OpenBootloader/Core/: openbl_core.c
  group Middlewares/Modules/I2C
    ../../../../../Middlewares/ST/OpenBootloader/Modules/I2C/: openbl_i2c_cmd.c
  group Middlewares/Modules/MEM
    ../../../../../Middlewares/ST/OpenBootloader/Modules/Mem/: openbl_mem.c
  group Middlewares/Modules/SPI
    ../../../../../Middlewares/ST/OpenBootloader/Modules/SPI/: openbl_spi_cmd.c
  group Middlewares/Modules/USART
    ../../../../../Middlewares/ST/OpenBootloader/Modules/USART/: openbl_usart_cmd.c
