# Keil uVision project Zigbee_Skeleton.uvprojx, settings and files
target Zigbee_Skeleton (6190000::V6.19::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: Zigbee_Skeleton +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,MAC,MAC_LAYER,USE_HAL_DRIVER,STM32WBA55xx
  c misc: -mno-unaligned-access -fshort-enums
  c include: ../Core/Inc;../System/Interfaces;../System/Modules;../System/Modules/baes;../System/Modules/MemoryManager;../System/Modules/RTDebug;../System/Modules/RFControl;../System/Modules/SerialCmdInterpreter;../System/Config/Log;../System/Config/LowPower;../System/Config/Debug_GPIO;../System/Config/CRC_Ctrl;../STM32_WPAN/Target;../../../../../../Utilities/trace/adv_trace;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/tim_serv;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ieee_15_4_basic;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/se;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/general;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/key;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/se;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/security;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/zd;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zgp;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port/mac;../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port/stm32wba;../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32wba55xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/System/Startup
    ../System/Startup/: stm32wbaxx_ResetHandler.S
  group Application/User/System/Modules
    ../System/Modules/: app_sys.c crc_ctrl.c otp.c scm.c stm_list.c
  group Application/User/System/Modules/baes
    ../System/Modules/baes/: baes_cmac.c baes_ecb.c
  group Application/User/System/Modules/MemoryManager
    ../System/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Application/User/System/Modules/SerialCmdInterpreter
    ../System/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Application/User/System/Modules/RFControl
    ../System/Modules/RFControl/: rf_antenna_switch.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: hw_aes.c hw_rng.c stm32_lpm_if.c timer_if.c usart_if.c
  group Application/User/System/Config/Log
    ../System/Config/Log/: log_module.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: power_table.c linklayer_plat.c ll_sys_if.c mac_sys_if.c zigbee_plat.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: Linklayer15_4.a
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/: ZigbeeProR23_FFD.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/: ZigbeeClusters.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
