<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_PressMeas_Client_Coord_Persist.ewp</path>
    </project>
    <batchBuild />
</workspace>
