<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_Thermostat_Client_Coord_R22.ewp</path>
    </project>
    <batchBuild />
</workspace>
