<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Zigbee_Messaging_Server_Router_R22-SE.ewp</path>
  </project>
  <batchBuild />
</workspace>
