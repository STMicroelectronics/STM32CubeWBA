<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Zigbee_FindBind_IAS_Router.ewp</path>
    </project>
    <batchBuild />
</workspace>
