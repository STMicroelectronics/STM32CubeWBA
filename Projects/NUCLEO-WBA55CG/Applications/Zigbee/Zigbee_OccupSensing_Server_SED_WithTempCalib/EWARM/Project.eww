<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Zigbee_OccupSensing_Server_SED_WithTempCalib.ewp</path>
  </project>
  <batchBuild />
</workspace>
