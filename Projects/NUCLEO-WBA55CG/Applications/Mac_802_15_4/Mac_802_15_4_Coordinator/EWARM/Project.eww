<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Project.ewp</path>
    </project>
    <batchBuild>
        <batchDefinition>
            <name>MAC_Certification_with_libs</name>
            <member>
                <project>Project</project>
                <configuration>LinkLayer_lib</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>wba_mac_lib</configuration>
            </member>
            <member>
                <project>Project</project>
                <configuration>ST_MAC_Export</configuration>
            </member>
        </batchDefinition>
    </batchBuild>
</workspace>
