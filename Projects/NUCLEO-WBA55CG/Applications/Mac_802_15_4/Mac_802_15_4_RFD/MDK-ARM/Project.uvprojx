# Keil uVision project Project.uvprojx, settings and files
target Mac_802_15_4_RFD_Demo_Export (6190000::V6.19::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf #L --bin --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32WBA55xx,USE_HAL_DRIVER,USE_FULL_ASSERT,USE_FULL_LL_DRIVER,PHY_2_10_a,PHY_40nm_2_30_a_A1,LOGGER_ENABLE=0,MAC,MAC_LAYER,OS_BAREMETAL
  c misc: -fshort-enums
  c include: ../Core/Inc;../STM32_WPAN/App/Inc;../System/Interfaces;../System/Modules;../System/Config/LowPower;../System/Config/Debug_GPIO;../System/Modules/RTDebug;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Middlewares/ST/STM32_WPAN/;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ieee_15_4_basic;../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/core/inc;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting;../../../../../../Utilities/trace/adv_trace;../../../../../../Utilities/misc;../../../../../../Utilities/sequencer;../../../../../../Utilities/lpm/tiny_lpm;../../../../../../Utilities/tim_serv;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../System/Config/Log;../System/Modules/SerialCmdInterpreter;../STM32_WPAN/Target;../System/Startup;..\System\Config\ADC_Ctrl;..\System\Config\CRC_Ctrl
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: stm32wba55xx_flash.sct
  link misc: --diag_suppress=L6329
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba55xx.s
  group Application/User/Core
    ../Core/src/: app_entry.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/src/: app_mac.c app_mac_802_15_4_process.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bpka.c linklayer_plat.c ll_sys_if.c mac_sys_if.c power_table.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Log
    ../System/Config/Log/: log_module.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Config/ADC_Ctrl
    ../System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: hw_aes.c hw_otp.c hw_pka.c hw_rng.c pka_p256.c stm32_lpm_if.c timer_if.c
  group Application/User/System/Modules
    ../System/Modules/: adc_ctrl.c app_sys.c otp.c scm.c stm_list.c temp_measurement.c
    ../System/Interfaces/: usart_if.c
  group Application/User/System/Modules/baes
    ../System/Modules/baes/: baes_cmac.c baes_ecb.c
  group Application/User/System/Modules/Nvm
    ../System/Modules/Nvm/: nvm_emul.c
  group Application/User/System/Modules/RFControl
    ../System/Modules/RFControl/: rf_antenna_switch.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Application/User/System/Modules/SerialCmdInterpreter
    ../System/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Application/User/System/Startup
    ../System/Startup/: stm32wbaxx_ResetHandler.S
  group Drivers/BSP
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Source/Templates/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_comp.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_hash_ex.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_irda.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_msp_template.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_smartcard.c stm32wbaxx_hal_smartcard_ex.c stm32wbaxx_hal_smbus.c stm32wbaxx_hal_smbus_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_timebase_rtc_alarm_template.c stm32wbaxx_hal_timebase_rtc_wakeup_template.c stm32wbaxx_hal_timebase_tim_template.c stm32wbaxx_hal_tsc.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_hal_wwdg.c stm32wbaxx_ll_adc.c stm32wbaxx_ll_comp.c stm32wbaxx_ll_crc.c stm32wbaxx_ll_dma.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_i2c.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_lptim.c stm32wbaxx_ll_lpuart.c stm32wbaxx_ll_pka.c stm32wbaxx_ll_pwr.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_rng.c stm32wbaxx_ll_rtc.c stm32wbaxx_ll_spi.c stm32wbaxx_ll_tim.c stm32wbaxx_ll_usart.c stm32wbaxx_ll_utils.c
  group libs
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer15_4.a
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/ST/Link Layer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
