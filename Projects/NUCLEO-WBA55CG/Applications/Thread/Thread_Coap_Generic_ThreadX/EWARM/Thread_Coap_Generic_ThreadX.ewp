# IAR project Thread_Coap_Generic_ThreadX.ewp, settings and files
configuration Thread_Coap_Generic_ThreadX (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_FULL_ASSERT; PHY_2_10_a; PHY_40nm_2_30_a_A1; OPENTHREAD_FTD; OPENTHREAD_CONFIG_FILE=<stm32wba-openthread-ftd-config.h>; OPENTHREAD_PROJECT_CORE_CONFIG_FILE=<stm32wba-openthread-ftd-config.h>; MAC; STM32; STM32WBA; STM32WBA55xx; STM32WBA55CGUx; USE_HAL_DRIVER; TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE
  ICCARM.CCIncludePath2: ../Core/Inc; ../System/Interfaces; ../System/Modules; ../System/Modules/baes; ../System/Modules/MemoryManager; ../System/Modules/RTDebug; ../System/Modules/RFControl; ../System/Modules/SerialCmdInterpreter; ../System/Config/Log; ../System/Config/LowPower; ../System/Config/Debug_GPIO; ../STM32_WPAN/App; ../STM32_WPAN/Target; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/tim_serv; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Middlewares/ST/threadx/common/inc; ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/inc; ../../../../../../Middlewares/ST/threadx/utility/low_power; ../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/thread; ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/common; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/config; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/platform; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/openthread; ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/stack/include/sys; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: Thread_Coap_Generic.hex
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba55xx.s
  group Application/User/AZURE_RTOS/App
    ../AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/Core
    ../Core/Src/: app_entry.c app_threadx.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_hal_timebase_tim.c stm32wbaxx_it.c tx_initialize_low_level.S
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_thread.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: linklayer_plat.c ll_sys_if.c power_table.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Log
    ../System/Config/Log/: log_module.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: hw_aes.c hw_rng.c stm32_lpm_if.c timer_if.c usart_if.c
  group Application/User/System/Modules
    ../System/Modules/: app_sys.c otp.c scm.c stm_list.c
  group Application/User/System/Modules/baes
    ../System/Modules/baes/: baes_cmac.c baes_ecb.c
  group Application/User/System/Modules/MemoryManager
    ../System/Modules/MemoryManager/: memory_manager.c stm32_mm.c
  group Application/User/System/Modules/RFControl
    ../System/Modules/RFControl/: rf_antenna_switch.c
  group Application/User/System/Modules/RTDebug
    ../System/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Application/User/System/Modules/SerialCmdInterpreter
    ../System/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Application/User/System/Startup
    ../System/Startup/: stm32wbaxx_ResetHandler.S
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Middlewares/AzureRTOS/threadx/common
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_search.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_semaphore_ceiling_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_thread_create.c tx_thread_initialize.c tx_thread_shell_entry.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_time_slice.c tx_thread_timeout.c tx_timer_expiration_process.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_byte_allocate.c txe_byte_pool_create.c txe_mutex_create.c txe_mutex_get.c txe_mutex_put.c txe_semaphore_ceiling_put.c txe_semaphore_create.c txe_semaphore_get.c txe_semaphore_put.c txe_thread_create.c
  group Middlewares/AzureRTOS/threadx/debug_traces
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c
  group Middlewares/AzureRTOS/threadx/ports/cortex_m33/iar/src
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Middlewares/AzureRTOS/threadx/utility/low_power
    ../../../../../../Middlewares/ST/threadx/utility/low_power/: tx_low_power.c
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/platform/: alarm.c diag.c entropy_renamed.c flash.c logging_stm32wba.c misc.c spi-stubs.c system.c uart.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_Thread_lib.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/thread/openthread/openthread_lib/: stm32wba_ot_ftd_lib.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
