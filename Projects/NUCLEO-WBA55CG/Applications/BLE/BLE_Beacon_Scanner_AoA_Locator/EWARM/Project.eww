<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_Beacon_Scanner_AoA_Locator.ewp</path>
  </project>
  <batchBuild />
</workspace>
