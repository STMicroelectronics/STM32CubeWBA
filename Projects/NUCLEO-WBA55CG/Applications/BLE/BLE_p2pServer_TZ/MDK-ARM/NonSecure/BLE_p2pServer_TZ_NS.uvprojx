# Keil uVision project BLE_p2pServer_TZ_NS.uvprojx, settings and files
target BLE_p2pServer_TZ_NS (6190000::V6.19::ARMCLANG)
  device: STM32WBA55CGUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.3.0
  cpu: IRAM(0x20010000-0x2001FFFF) IROM(0x08080000-0x80FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BLE_p2pServer_TZ_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA55xx,BLE
  c misc: -fshort-enums
  c include: ../../NonSecure/Core/Inc;../../Secure_nsclib;../../NonSecure/System/Interfaces;../../NonSecure/System/Modules;../../NonSecure/System/Modules/baes;../../NonSecure/System/Modules/Flash;../../NonSecure/System/Modules/MemoryManager;../../NonSecure/System/Modules/Nvm;../../NonSecure/System/Modules/RTDebug;../../NonSecure/System/Modules/RFControl;../../NonSecure/System/Modules/SerialCmdInterpreter;../../NonSecure/System/Config/Log;../../NonSecure/System/Config/LowPower;../../NonSecure/System/Config/Debug_GPIO;../../NonSecure/System/Config/Flash;../../NonSecure/System/Config/CRC_Ctrl;../../NonSecure/STM32_WPAN/App;../../NonSecure/STM32_WPAN/Target;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../../Utilities/trace/adv_trace;../../../../../../../Utilities/misc;../../../../../../../Utilities/sequencer;../../../../../../../Utilities/tim_serv;../../../../../../../Utilities/lpm/tiny_lpm;../../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_basic;../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc;../../../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include;../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto;../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../../../../../../Drivers/CMSIS/Include;../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../NonSecure/System/Config/ADC_Ctrl
  memory RVCT4: ROM 0x8080000 size 0x80000
  memory RVCT9: RAM 0x20010000 size 0x10000
  scatter file: stm32wba55xx_flash_ns.sct
  link misc: ../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba55xx.s
  group Application/User/NonSecure/System/Modules
    ../../NonSecure/System/Modules/: adc_ctrl.c app_sys.c ble_timer.c crc_ctrl.c otp.c scm.c stm_list.c temp_measurement.c
  group Application/User/NonSecure/System/Modules/baes
    ../../NonSecure/System/Modules/baes/: baes_cmac.c baes_ecb.c
  group Application/User/NonSecure/System/Modules/SerialCmdInterpreter
    ../../NonSecure/System/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Application/User/NonSecure/System/Modules/MemoryManager
    ../../NonSecure/System/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Application/User/NonSecure/System/Modules/Nvm
    ../../NonSecure/System/Modules/Nvm/: nvm_emul.c
  group Application/User/NonSecure/System/Modules/RFControl
    ../../NonSecure/System/Modules/RFControl/: rf_antenna_switch.c
  group Application/User/NonSecure/System/Modules/Flash
    ../../NonSecure/System/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Application/User/NonSecure/System/Modules/RTDebug
    ../../NonSecure/System/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Application/User/NonSecure/System/Config/Debug_GPIO
    ../../NonSecure/System/Config/Debug_GPIO/: app_debug.c
  group Application/User/NonSecure/System/Config/Log
    ../../NonSecure/System/Config/Log/: log_module.c
  group Application/User/NonSecure/System/Config/Flash
    ../../NonSecure/System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/NonSecure/System/Config/CRC_Ctrl
    ../../NonSecure/System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/NonSecure/System/Config/LowPower
    ../../NonSecure/System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/NonSecure/System/Startup
    ../../NonSecure/System/Startup/: stm32wbaxx_ResetHandler.S
  group Application/User/NonSecure/System/Interfaces
    ../../NonSecure/System/Interfaces/: hw_aes.c hw_otp.c hw_pka.c hw_rng.c pka_p256.c stm32_lpm_if.c timer_if.c usart_if.c
  group Application/User/NonSecure/Core
    ../../NonSecure/Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/NonSecure/STM32_WPAN/App
    ../../NonSecure/STM32_WPAN/App/: app_ble.c p2p_server.c p2p_server_app.c
  group Application/User/NonSecure/STM32_WPAN/Target
    ../../NonSecure/STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c bpka.c ll_sys_if.c host_stack_if.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../NonSecure/Core/Src/: system_stm32wbaxx_ns.c
  group Middlewares/STM32_WPAN
    ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Basic_lib.a
    ../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_basic.a
    ../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
    ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Application/User/NonSecure/System/Config/ADC_Ctrl
    ./: 
    ../../NonSecure/System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Drivers/STM32WBAxx_HAL_Driver
    ./: 
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c
  group Utilities
    ./: 
    ../../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
