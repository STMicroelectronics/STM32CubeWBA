# IAR project BLE_p2pServer_TZ_NS.ewp, settings and files
configuration BLE_p2pServer_TZ_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA55xx; USE_FULL_LL_DRIVER; BLE_LL; PHY_40nm_3_00_a; BLE_STACK_BASIC_FEATURES
  ICCARM.CCIncludePath2: ../../NonSecure/Core/Inc; ../../Secure_nsclib; ../../NonSecure/System/Interfaces; ../../NonSecure/System/Modules; ../../NonSecure/System/Config/Log; ../../NonSecure/System/Config/LowPower; ../../NonSecure/System/Config/Debug_GPIO; ../../NonSecure/System/Config/Flash; ../../NonSecure/System/Config/ADC_Ctrl; ../../NonSecure/System/Config/CRC_Ctrl; ../../NonSecure/STM32_WPAN/App; ../../NonSecure/STM32_WPAN/Target; ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo; ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../../Utilities/trace/adv_trace; ../../../../../../../Projects/Common/WPAN/Interfaces; ../../../../../../../Projects/Common/WPAN/Modules; ../../../../../../../Projects/Common/WPAN/Modules/BasicAES; ../../../../../../../Projects/Common/WPAN/Modules/Flash; ../../../../../../../Projects/Common/WPAN/Modules/MemoryManager; ../../../../../../../Projects/Common/WPAN/Modules/RTDebug; ../../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter; ../../../../../../../Projects/Common/WPAN/Modules/Log; ../../../../../../../Utilities/misc; ../../../../../../../Utilities/sequencer; ../../../../../../../Utilities/tim_serv; ../../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../../Middlewares/ST/STM32_WPAN; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_basic; ../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc; ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc; ../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include; ../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto; ../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../../../Drivers/CMSIS/Include; ../../NonSecure/System/Config
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_p2pServer_TZ_NS.hex
  ILINK.IlinkOutputFile: BLE_p2pServer_TZ_NS.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash_ns.icf
  ILINK.IlinkAdditionalLibs: ../../Secure_nsclib/secure_nsclib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32wba55xx.s
  group Application/User/NonSecure/Common/WPAN/Interface
    ../../../../../../Common/WPAN/Interfaces/: app_bsp.c
  group Application/User/NonSecure/Core
    ../../NonSecure/Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Application/User/NonSecure/STM32_WPAN/App
    ../../NonSecure/STM32_WPAN/App/: app_ble.c p2p_server.c p2p_server_app.c
  group Application/User/NonSecure/STM32_WPAN/Target
    ../../NonSecure/STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c ll_sys_if.c host_stack_if.c
  group Application/User/NonSecure/System/Config/ADC_Ctrl
    ../../NonSecure/System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Application/User/NonSecure/System/Config/CRC_Ctrl
    ../../NonSecure/System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/NonSecure/System/Config/Debug_GPIO
    ../../NonSecure/System/Config/Debug_GPIO/: app_debug.c
  group Application/User/NonSecure/System/Config/Flash
    ../../NonSecure/System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/NonSecure/System/Config/LowPower
    ../../NonSecure/System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/NonSecure/System/Interfaces
    ../../NonSecure/System/Interfaces/: stm32_lpm_if.c
  group Application/User/NonSecure/System/Modules
    ../../NonSecure/System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../../Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_rng.c timer_if.c
    ../../../../../../../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../../Common/WPAN/Modules/: adc_ctrl.c app_sys.c crc_ctrl.c otp.c pka_ctrl.c scm.c stm_list.c stm_queue.c temp_measurement.c wpan_utils.c
    ../../../../../../../Projects/Common/WPAN/Modules/: adc_ctrl.c app_sys.c crc_ctrl.c otp.c pka_ctrl.c scm.c stm_list.c stm_queue.c temp_measurement.c wpan_utils.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../../Common/WPAN/Modules/BasicAES/: baes_ccm.c baes_cmac.c baes_ecb.c
    ../../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../../Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
    ../../../../../../../Projects/Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/Log
    ../../../../../../Common/WPAN/Modules/Log/: log_module.c
    ../../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../../Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
    ../../../../../../../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../../Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
    ../../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../../Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
    ../../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../../Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
    ../../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../NonSecure/Core/Src/: system_stm32wbaxx_ns.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_ll_pka.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_ll_utils.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_adc.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Basic_V3_0.a
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Utilities
    ../../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
