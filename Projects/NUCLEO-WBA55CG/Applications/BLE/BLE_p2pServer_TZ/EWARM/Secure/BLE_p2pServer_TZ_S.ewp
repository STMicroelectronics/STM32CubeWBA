# IAR project BLE_p2pServer_TZ_S.ewp, settings and files
configuration BLE_p2pServer_TZ_S (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA55CG ST STM32WBA55CG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA55xx
  ICCARM.CCIncludePath2: ../../Secure/Core/Inc; ../../Secure_nsclib; ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo; ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_p2pServer_TZ_S.hex
  ILINK.IlinkOutputFile: BLE_p2pServer_TZ_S.out
  ILINK.IlinkIcfFile: stm32wba55xx_flash_s.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../: startup_stm32wba55xx.s
    ../../../../../../NUCLEO-WBA65RI/Applications/BLE/BLE_p2pServer_TZ/EWARM/: stm32wbaxx_ResetHandler_S.s
  group Application/User/Secure/Core
    ../../Secure/Core/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../Secure/Core/Src/: system_stm32wbaxx_s.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_pka.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c
