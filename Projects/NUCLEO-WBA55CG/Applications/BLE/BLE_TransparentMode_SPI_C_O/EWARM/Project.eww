<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_TransparentMode_SPI_C_O.ewp</path>
  </project>
  <batchBuild />
</workspace>
