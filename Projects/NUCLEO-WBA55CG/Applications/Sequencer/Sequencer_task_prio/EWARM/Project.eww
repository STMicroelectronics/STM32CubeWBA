<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Sequencer_task_prio.ewp</path>
  </project>
  <batchBuild />
</workspace>
