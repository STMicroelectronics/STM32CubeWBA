# IAR project TrustZoneEnabled_NoIsolation.ewp, settings and files
configuration TrustZoneEnabled_NoIsolation (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA5MJG ST STM32WBA5MJG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WBA5Mxx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/B-WBA5M-WPAN
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneEnabled_NoIsolation.hex
  ILINK.IlinkOutputFile: TrustZoneEnabled_NoIsolation.out
  ILINK.IlinkIcfFile: stm32wba5mxx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba5mxx.s
  group Application/User
    ../Src/: main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Doc
    ../: README.md
  group Drivers/BSP/B-WBA5M-WPAN
    ../../../../../Drivers/BSP/B-WBA5M-WPAN/: b_wba5m_wpan.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c
