# IAR project TrustZoneDisabled.ewp, settings and files
configuration TrustZoneDisabled (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA5MJG ST STM32WBA5MJG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; HSE_VALUE=32000000; HSE_STARTUP_TIMEOUT=100; LSE_STARTUP_TIMEOUT=5000; LSE_VALUE=32768; EXTERNALSAI1_CLOCK_VALUE=48000; HSI_VALUE=16000000; LSI_VALUE=32000; VDD_VALUE=3300; PREFETCH_ENABLE=1; STM32WBA5Mxx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include; ../../../../../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TrustZoneDisabled.hex
  ILINK.IlinkOutputFile: TrustZoneDisabled.out
  ILINK.IlinkIcfFile: stm32wba5mxx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba5mxx.s
  group Application/User
    ../Src/: main.c stm32wbaxx_it.c
  group Doc
    ../: README.md
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_pwr.c stm32wbaxx_ll_utils.c
