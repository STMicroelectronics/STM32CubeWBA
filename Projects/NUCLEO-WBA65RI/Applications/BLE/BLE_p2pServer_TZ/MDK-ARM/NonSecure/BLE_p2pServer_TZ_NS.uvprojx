# Keil uVision project BLE_p2pServer_TZ_NS.uvprojx, settings and files
target BLE_p2pServer_TZ_NS (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.6.0-B01
  cpu: IRAM(0x20040000-0x2007FFFF) IROM(0x08100000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BLE_p2pServer_TZ_NS +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA65xx,PHY_40nm_3_40_a,USE_FULL_LL_DRIVER,BLE_LL,BLE_STACK_BASIC_FEATURES
  c misc: -fshort-enums
  c include: ../../NonSecure/Core/Inc;../../Secure_nsclib;../../NonSecure/System/Interfaces;../../NonSecure/System/Modules;../../NonSecure/System/Config;../../NonSecure/System/Config/Log;../../NonSecure/System/Config/LowPower;../../NonSecure/System/Config/Debug_GPIO;../../NonSecure/System/Config/Flash;../../NonSecure/System/Config/ADC_Ctrl;../../NonSecure/System/Config/CRC_Ctrl;../../NonSecure/STM32_WPAN/App;../../NonSecure/STM32_WPAN/Target;../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../../Utilities/trace/adv_trace;../../../../../../../Projects/Common/WPAN/Interfaces;../../../../../../../Projects/Common/WPAN/Modules;../../../../../../../Projects/Common/WPAN/Modules/BasicAES;../../../../../../../Projects/Common/WPAN/Modules/Flash;../../../../../../../Projects/Common/WPAN/Modules/MemoryManager;../../../../../../../Projects/Common/WPAN/Modules/Nvm;../../../../../../../Projects/Common/WPAN/Modules/RTDebug;../../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter;../../../../../../../Projects/Common/WPAN/Modules/Log;../../../../../../../Utilities/misc;../../../../../../../Utilities/sequencer;../../../../../../../Utilities/tim_serv;../../../../../../../Utilities/lpm/tiny_lpm;../../../../../../../Middlewares/ST/STM32_WPAN;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/config/ble_basic;../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/_40nm_reg_files;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/inc/ot_inc;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/porting;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/inc;../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/src/shrd_utils/inc;../../../../../../../Middlewares/ST/STM32_WPAN/ble;../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include;../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/include/auto;../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8100000 size 0x100000
  memory RVCT9: RAM 0x20040000 size 0x40000
  scatter file: stm32wba65xx_flash_ns.sct
  link misc: ../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba65xx.s
  group Application/User/NonSecure/STM32_WPAN/App
    ../../NonSecure/STM32_WPAN/App/: app_ble.c p2p_server.c p2p_server_app.c
  group Application/User/NonSecure/STM32_WPAN/Target
    ../../NonSecure/STM32_WPAN/Target/: bleplat.c power_table.c linklayer_plat.c ll_sys_if.c host_stack_if.c
  group Application/User/NonSecure/System/Config/Flash
    ../../NonSecure/System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/NonSecure/System/Config/CRC_Ctrl
    ../../NonSecure/System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/NonSecure/System/Config/LowPower
    ../../NonSecure/System/Config/LowPower/: user_low_power_config.c peripheral_init.c
  group Application/User/NonSecure/System/Config/Debug_GPIO
    ../../NonSecure/System/Config/Debug_GPIO/: app_debug.c
  group Application/User/NonSecure/System/Config/ADC_Ctrl
    ../../NonSecure/System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Application/User/NonSecure/System/Interfaces
    ../../NonSecure/System/Interfaces/: stm32_lpm_if.c
  group Application/User/NonSecure/System/Modules
    ../../NonSecure/System/Modules/: ble_timer.c
  group Application/User/NonSecure/Core
    ../../NonSecure/Core/Src/: main.c app_entry.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../NonSecure/Core/Src/: system_stm32wbaxx_ns.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_ll_pka.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_ll_utils.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_gpio.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_ll_tim.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_adc.c
  group Application/User/NonSecure/Common/WPAN/Interface
    ../../../../../../Common/WPAN/Interfaces/: app_bsp.c
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Common/WPAN/Interface
    ./: 
    ../../../../../../../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_otp.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/: adc_ctrl.c app_sys.c crc_ctrl.c otp.c pka_ctrl.c scm.c stm_list.c stm_queue.c temp_measurement.c wpan_utils.c
  group Common/WPAN/Modules/BasicAES
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_cmac.c baes_ccm.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/Log
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RTDebug
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ./: 
    ../../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ./: 
    ../../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_MDK-ARM.s
  group Middlewares/STM32_WPAN/LinkLayer
    ./: 
    ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Basic_V3_0.a
  group Middlewares/STM32_WPAN/BLE
    ./: 
    ../../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Utilities
    ./: 
    ../../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../../Utilities/tim_serv/: stm32_timer.c
    ../../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
software components: CMSIS:CORE 4.3.0
