# Keil uVision project BLE_p2pServer_TZ_S.uvprojx, settings and files
target BLE_p2pServer_TZ_S (6190000::V6.19::ARMCLANG)
  device: STM32WBA65RIVx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.6.0-B02
  cpu: IRAM(0x30000000-0x3003FFFF) IROM(0x0C000000-0xC0FDFFF) IROM2(0x0C0FE000-0xC0FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: BLE_p2pServer_TZ_S +hex
  AfterMake: fromelf #L --bincombined  --output=$L@L.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA65xx
  c misc: -fshort-enums
  c include: ../../Secure/Core/Inc;../../Secure_nsclib;../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0xc000000 size 0xfe000
  memory RVCT5: ROM 0xc0fe000 size 0x2000
  memory RVCT9: RAM 0x30000000 size 0x40000
  scatter file: stm32wba65xx_flash_s.sct
  link misc: --import_cmse_lib_out=../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba65xx.s stm32wbaxx_ResetHandler_S.s
  group Application/User/Secure/Core
    ../../Secure/Core/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c secure_nsc.c
  group Doc
    ../../: README.md
  group Drivers/CMSIS
    ../../Secure/Core/Src/: system_stm32wbaxx_s.c
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_pka.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_ll_exti.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c
software components: CMSIS:CORE 4.3.0
