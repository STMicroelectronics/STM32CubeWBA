# IAR project Zigbee_OnOff_Client_Router_ThreadX.ewp, settings and files
configuration Zigbee_OnOff_Client_Router_ThreadX (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32; STM32WBA; STM32WBA65xx; STM32WBA65RIx; USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; MAC; MAC_LAYER; APPLICATION_USE_THREADX; TX_INCLUDE_USER_DEFINE_FILE; TX_SINGLE_MODE_NON_SECURE; APPLICATION_USE_NUCLEO; APPLICATION_USE_HW_AES; APPLICATION_USE_HW_RNG; APPLICATION_USE_AMM; APPLICATION_USE_SMPS
  ICCARM.IExtraOptions: --aeabi; --guard_calls; --diag_suppress Pa183
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STM32_WPAN\App; ..\STM32_WPAN\Target; ..\System\Config\CRC_Ctrl; ..\System\Config\Debug_GPIO; ..\System\Config\Log; ..\System\Config\LowPower; ..\System\Interfaces; ..\..\..\..\..\..\Projects\Common\WPAN\Interfaces; ..\..\..\..\..\..\Projects\Common\WPAN\Modules; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\BasicAES; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\Flash; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\Log; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\MemoryManager; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\RTDebug; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\SerialCmdInterpreter; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\Drivers\CMSIS\RTOS2\Include; ..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\stack\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\stack\port\stm32wba; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\stack\port\mac; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\mac_802_15_4\core\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_sys\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\config\ieee_15_4_basic; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\ot_inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\utilities; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\interface; ..\..\..\..\..\..\Utilities\conf; ..\..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\..\Utilities\misc; ..\..\..\..\..\..\Utilities\tim_serv; ..\..\..\..\..\..\Utilities\trace\adv_trace; ..\..\..\..\..\..\Middlewares\ST\threadx\utility\low_power; ..\..\..\..\..\..\Middlewares\ST\threadx\ports\cortex_m33\iar\inc; ..\..\..\..\..\..\Middlewares\ST\threadx\common\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: TX_SINGLE_MODE_NON_SECURE
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: $CONFIG_NAME$.hex
  postbuild: ielftool $EXE_DIR$\$CONFIG_NAME$.out $EXE_DIR$\$CONFIG_NAME$.bin --bin
  ILINK.IlinkOutputFile: $CONFIG_NAME$.out
  ILINK.IlinkIcfFile: stm32wba65xx_flash_threadx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba65xx.s
  group Application/User/AZURE_RTOS/App
    ../AZURE_RTOS/App/: app_azure_rtos.c
  group Application/User/Core
    ../Core/Src/: app_entry.c app_threadx.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_hal_timebase_tim.c stm32wbaxx_it.c tx_initialize_low_level.S
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_bsp.c app_zigbee.c app_zigbee_endpoint.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: linklayer_plat.c ll_sys_if.c mac_sys_if.c power_table.c zigbee_plat.c zigbee_sys_if.c
  group Application/User/System/Config/CRC_Ctrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Common/WPAN/Interfaces
    ../../../../../../Projects/Common/WPAN/Interfaces/: adv_trace_usart_if.c hw_aes.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../../Projects/Common/WPAN/Modules/: app_sys.c crc_ctrl.c otp.c scm.c stm_list.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../../Projects/Common/WPAN/Modules/BasicAES/: baes_ccm.c baes_cmac.c baes_ecb.c
  group Common/WPAN/Modules/Log
    ../../../../../../Projects/Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../../Projects/Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RFControl
    ../../../../../../Projects/Common/WPAN/Modules/RFControl/: rf_antenna_switch.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../../Projects/Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../../Projects/Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../../Projects/Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../: readme.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_comp.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_gtzc.c stm32wbaxx_hal_hash.c stm32wbaxx_hal_hsem.c stm32wbaxx_hal_i2c.c stm32wbaxx_hal_i2c_ex.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_irda.c stm32wbaxx_hal_iwdg.c stm32wbaxx_hal_lptim.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_sai.c stm32wbaxx_hal_sai_ex.c stm32wbaxx_hal_smartcard.c stm32wbaxx_hal_smartcard_ex.c stm32wbaxx_hal_smbus.c stm32wbaxx_hal_smbus_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_tim.c stm32wbaxx_hal_tim_ex.c stm32wbaxx_hal_tsc.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_usart.c stm32wbaxx_hal_usart_ex.c stm32wbaxx_hal_wwdg.c stm32wbaxx_ll_rcc.c stm32wbaxx_ll_tim.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: WBA6_LinkLayer15_4.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Middlewares/STM32_WPAN/Mac_802_15_4
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/STM32_WPAN/Zigbee
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/: ZigBeeClusters.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/: ZigBeeProR23_FFD.a
  group Middlewares/ThreadX/common
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_byte_allocate.c tx_byte_pool_cleanup.c tx_byte_pool_create.c tx_byte_pool_search.c tx_byte_release.c tx_initialize_high_level.c tx_initialize_kernel_enter.c tx_initialize_kernel_setup.c tx_mutex_cleanup.c tx_mutex_create.c tx_mutex_delete.c tx_mutex_get.c tx_mutex_prioritize.c tx_mutex_priority_change.c tx_mutex_put.c tx_semaphore_cleanup.c tx_semaphore_create.c tx_semaphore_get.c tx_semaphore_initialize.c tx_semaphore_prioritize.c tx_semaphore_put.c tx_thread_create.c tx_thread_initialize.c tx_thread_relinquish.c tx_thread_resume.c tx_thread_shell_entry.c tx_thread_sleep.c tx_thread_system_preempt_check.c tx_thread_system_resume.c tx_thread_system_suspend.c tx_thread_time_slice.c tx_thread_timeout.c tx_timer_expiration_process.c tx_timer_initialize.c tx_timer_system_activate.c tx_timer_system_deactivate.c tx_timer_thread_entry.c txe_byte_allocate.c txe_byte_pool_create.c txe_byte_release.c txe_mutex_create.c txe_mutex_get.c txe_mutex_put.c txe_semaphore_create.c txe_semaphore_get.c txe_semaphore_put.c txe_thread_create.c txe_thread_relinquish.c txe_thread_resume.c
  group Middlewares/ThreadX/debug_trace
    ../../../../../../Middlewares/ST/threadx/common/src/: tx_trace_buffer_full_notify.c tx_trace_disable.c tx_trace_enable.c tx_trace_event_filter.c tx_trace_event_unfilter.c tx_trace_initialize.c tx_trace_interrupt_control.c tx_trace_isr_enter_insert.c tx_trace_isr_exit_insert.c tx_trace_object_register.c tx_trace_object_unregister.c tx_trace_user_event_insert.c
  group Middlewares/ThreadX/ports/cortex_m33/iar/src
    ../../../../../../Middlewares/ST/threadx/ports/cortex_m33/iar/src/: tx_iar.c tx_thread_context_restore.s tx_thread_context_save.s tx_thread_interrupt_control.s tx_thread_interrupt_disable.s tx_thread_interrupt_restore.s tx_thread_schedule.s tx_thread_stack_build.s tx_thread_system_return.s tx_timer_interrupt.s
  group Middlewares/ThreadX/utility/low_power
    ../../../../../../Middlewares/ST/threadx/utility/low_power/: tx_low_power.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
