# IAR project BLE_HeartRate_Zigbee.ewp, settings and files
configuration BLE_HeartRate_Zigbee (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32; STM32WBA; STM32WBA65xx; STM32WBA65RIx; USE_HAL_DRIVER; USE_FULL_LL_DRIVER; BLE_LL; MAC; MAC_LAYER; APPLICATION_USE_BAREMETAL; APPLICATION_USE_PERSISTENCE; APPLICATION_USE_EEPROM; APPLICATION_USE_NUCLEO; APPLICATION_USE_HW_AES; APPLICATION_USE_HW_RNG; APPLICATION_USE_AMM; DISABLE_RFTS_EXT_EVNT_HNDLR=1; BLE_STACK_BASIC_FEATURES; CONFIG_ZB_REV=23
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\STM32_WPAN\App; ..\STM32_WPAN\Target; ..\System\Config\CRC_Ctrl; ..\System\Config\ADC_Ctrl; ..\System\Config\Debug_GPIO; ..\System\Config; ..\System\Config\Log; ..\System\Config\LowPower; ..\System\Config\Flash; ..\System\Interfaces; ..\System\Modules; ..\..\..\..\..\..\Utilities\trace\adv_trace; ..\..\..\..\..\..\Utilities\misc; ..\..\..\..\..\..\Utilities\sequencer; ..\..\..\..\..\..\Utilities\tim_serv; ..\..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\..\Utilities\conf; ..\..\..\..\..\..\Projects\Common\WPAN\Interfaces; ..\..\..\..\..\..\Projects\Common\WPAN\Modules; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\BasicAES; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\Flash; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\Log; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\MemoryManager; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\RTDebug; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\SerialCmdInterpreter; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\Nvm; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\config\concurrent\ble_basic_15_4; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\svc\Src; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_sys\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\stack\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\stack\include\auto; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\ble\svc\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\_40nm_reg_files; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\ot_inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\mac_802_15_4\core\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\mac_802_15_4\mac_utilities\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\include; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\stack\port\stm32wba; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\zigbee\stack\port\mac; ..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc\Legacy; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/general; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/key; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/se; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/security; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zcl/zd; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/include/zgp; ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/port
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BLE_HeartRate_Zigbee.bin
  ILINK.IlinkOutputFile: BLE_HeartRate_Zigbee.out
  ILINK.IlinkIcfFile: stm32wba65xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c app_zigbee.c app_zigbee_endpoint.c app_zigbee_utility.c dis.c dis_app.c hrs.c hrs_app.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: bleplat.c host_stack_if.c linklayer_plat.c ll_sys_if.c mac_sys_if.c power_table.c zigbee_plat.c zigbee_sys_if.c
  group Application/User/System/Config/ADC_Cntrl
    ../System/Config/ADC_Ctrl/: adc_ctrl_conf.c
  group Application/User/System/Config/CRC_Cntrl
    ../System/Config/CRC_Ctrl/: crc_ctrl_conf.c
  group Application/User/System/Config/Debug_GPIO
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/Flash
    ../System/Config/Flash/: simple_nvm_arbiter_conf.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules
    ../System/Modules/: ble_timer.c
  group Common/WPAN/Interface
    ../../../../../Common/WPAN/Interfaces/: hw_otp.c
  group Common/WPAN/Interfaces
    ../../../../../Common/WPAN/Interfaces/: adv_trace_usart_if.c app_bsp.c hw_aes.c hw_rng.c timer_if.c
  group Common/WPAN/Modules
    ../../../../../Common/WPAN/Modules/: app_sys.c crc_ctrl.c otp.c pka_ctrl.c scm.c stm_list.c stm_queue.c wpan_utils.c
  group Common/WPAN/Modules/BasicAES
    ../../../../../Common/WPAN/Modules/BasicAES/: baes_ccm.c baes_cmac.c baes_ecb.c
  group Common/WPAN/Modules/Flash
    ../../../../../Common/WPAN/Modules/Flash/: flash_driver.c flash_manager.c rf_timing_synchro.c simple_nvm_arbiter.c
  group Common/WPAN/Modules/Log
    ../../../../../Common/WPAN/Modules/Log/: log_module.c
  group Common/WPAN/Modules/MemoryManager
    ../../../../../Common/WPAN/Modules/MemoryManager/: advanced_memory_manager.c stm32_mm.c
  group Common/WPAN/Modules/RTDebug
    ../../../../../Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Common/WPAN/Modules/SerialCmdInterpreter
    ../../../../../Common/WPAN/Modules/SerialCmdInterpreter/: serial_cmd_interpreter.c
  group Common/WPAN/Startup
    ../../../../../Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_adc_ex.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_cryp.c stm32wbaxx_hal_cryp_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pka.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_pka.c stm32wbaxx_ll_tim.c
  group Middlewares/STM32_WPAN/BLE
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/stack/lib/: stm32wba_ble_stack_full.a
    ../../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: svc_ctl.c
  group Middlewares/STM32_WPAN/LinkLayer
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_BLE_Basic_802_15_4_V3_0.a Mac15_4_Concurrent_BLE_Basic.a
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/802_15_4_ll_porting/: mac_radio_port.c
  group Middlewares/STM32_WPAN/Mac_802_15_4
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/STM32_WPAN/Zigbee
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/clusters/: ZigBeeClusters.a
    ../../../../../../Middlewares/ST/STM32_WPAN/zigbee/stack/: ZigBeeProR23_FFD.a
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
