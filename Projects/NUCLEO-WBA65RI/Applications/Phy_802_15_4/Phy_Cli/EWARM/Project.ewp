# IAR project Project.ewp, settings and files
configuration Phy_Cli (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA65RI ST STM32WBA65RI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32WBA65xx; USE_HAL_DRIVER; USE_FULL_ASSERT; USE_FULL_LL_DRIVER; LOGGER_ENABLE=0; FULL_CERTIFICATION_CAPABLE=0; OS_BAREMETAL; MAC; MAC_LAYER
  ICCARM.CCIncludePath2: ..\Core\Inc; ../System/Interfaces; ..\STM32_WPAN\App; ..\..\..\..\..\Common\WPAN\Modules; ..\System\Config; ..\System\Config; ..\System\Config\Log; ..\System\Config\Debug_GPIO; ..\..\..\..\..\Common\WPAN\Modules\RTDebug; ..\System\Config\LowPower; ..\..\..\..\..\Common\WPAN\App\cli_runner; ..\STM32_WPAN\Target; ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc; ..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_sys\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\porting; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\mac_802_15_4\core\inc; ..\..\..\..\..\..\Utilities\trace\adv_trace; ..\..\..\..\..\..\Utilities\misc; ..\..\..\..\..\..\Utilities\sequencer; ..\..\..\..\..\..\Utilities\lpm\tiny_lpm; ..\..\..\..\..\..\Utilities\tim_serv; ..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\config\thread; ..\..\..\..\..\..\Middlewares\ST\STM32_WPAN\link_layer\ll_cmd_lib\inc\ot_inc; ..\..\..\..\..\..\Projects\Common\WPAN\Interfaces; ..\..\..\..\..\..\Projects\Common\WPAN\Modules; ..\..\..\..\..\..\Projects\Common\WPAN\Modules\RTDebug
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Phy_Cli.out
  ILINK.IlinkIcfFile: stm32wba65xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wba65xx.s
  group Application/User/Core
    ../Core/Src/: app_entry.c main.c stm32wbaxx_hal_msp.c stm32wbaxx_it.c
  group Application/User/Startup
    ../../../../../Common/WPAN/Startup/: stm32wbaxx_ResetHandler_EWARM.s
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_cli_runner.c app_cli_runner_ex.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: linklayer_plat.c ll_sys_if.c power_table.c
  group Application/User/System/Config
    ../System/Config/Debug_GPIO/: app_debug.c
  group Application/User/System/Config/LowPower
    ../System/Config/LowPower/: peripheral_init.c user_low_power_config.c
  group Application/User/System/Interfaces
    ../../../../../Common/WPAN/Interfaces/: hw_aes.c hw_rng.c timer_if.c
  group Application/User/System/Modules
    ../../../../../Common/WPAN/Modules/: app_sys.c otp.c pka_ctrl.c scm.c
    ../System/Interfaces/: stm32_lpm_if.c
  group Application/User/System/Modules/RTDebug
    ../../../../../Common/WPAN/Modules/RTDebug/: RTDebug.c RTDebug_dtb.c
  group Doc
    ../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/CMSIS
    ../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Source/Templates/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_adc.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_icache.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_ramcfg.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_rng.c stm32wbaxx_hal_rng_ex.c stm32wbaxx_hal_rtc.c stm32wbaxx_hal_rtc_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_ll_tim.c
  group lib
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_cmd_lib/lib/: LinkLayer_802_15_4_V3_0.a
    ../../../../../../Middlewares/ST/STM32_WPAN/mac_802_15_4/lib/: wba_mac_lib.a
  group Middlewares/STM32_WPAN
    ../../../../../../Middlewares/ST/STM32_WPAN/link_layer/ll_sys/src/: ll_sys_cs.c ll_sys_dp_slp.c ll_sys_intf.c ll_sys_startup.c
  group Utilities
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/tim_serv/: stm32_timer.c
