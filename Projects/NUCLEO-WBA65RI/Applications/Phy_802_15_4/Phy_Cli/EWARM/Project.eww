<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Phy_Cli.ewp</path>
  </project>
  <batchBuild />
</workspace>
