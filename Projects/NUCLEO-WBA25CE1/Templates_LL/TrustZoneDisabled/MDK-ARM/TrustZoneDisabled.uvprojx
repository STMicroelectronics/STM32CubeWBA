# Keil uVision project TrustZoneDisabled.uvprojx, settings and files
target TrustZoneDisabled (6190000::V6.19::ARMCLANG)
  device: STM32WBA25CEUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.1.6.0-B02
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: TrustZoneDisabled +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,HSE_VALUE=32000000,HSE_STARTUP_TIMEOUT=100,LSE_STARTUP_TIMEOUT=5000,LSE_VALUE=32768,EXTERNALSAI1_CLOCK_VALUE=48000,HSI_VALUE=16000000,LSI_VALUE=32000,VDD_VALUE=3300,PREFETCH_ENABLE=1,STM32WBA25xx
  c include: ../Inc;../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: stm32wba25xx_flash.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wba25xx.s
  group Application/User
    ../Src/: main.c stm32wbaxx_it.c
  group Doc
    ../: README.md
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_ll_utils.c stm32wbaxx_ll_exti.c stm32wbaxx_ll_gpio.c stm32wbaxx_ll_icache.c stm32wbaxx_ll_pwr.c
  group Drivers/CMSIS
    ../Src/: system_stm32wbaxx.c
software components: CMSIS:CORE 5.6.0
