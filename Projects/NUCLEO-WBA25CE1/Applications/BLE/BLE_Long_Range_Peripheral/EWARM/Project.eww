<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\BLE_Long_Range_Peripheral.ewp</path>
  </project>
  <batchBuild />
</workspace>
