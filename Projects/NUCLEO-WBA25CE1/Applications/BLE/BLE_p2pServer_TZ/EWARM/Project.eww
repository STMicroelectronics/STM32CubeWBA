<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Secure\BLE_p2pServer_TZ_S.ewp</path>
  </project><project>
    <path>$WS_DIR$\NonSecure\BLE_p2pServer_TZ_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
