# IAR project Project_ns.ewp, settings and files
configuration NUCLEO-WBA25CE_OEMiROT_Appli_TrustZone_NS (ARM, debug)
  General.OGChipSelectEditMenu: STM32WBA25CE ST STM32WBA25CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: STM32WBA25xx; USE_HAL_DRIVER
  ICCARM.CCIncludePath2: ..\..\NonSecure\Inc; ..\..\Secure_nsclib; ..\..\..\..\..\..\..\Drivers\STM32WBAxx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32WBAxx\Include\Templates; ..\..\..\..\..\..\..\Drivers\BSP\STM32WBAxx_Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\Components\mx25r3235f; ..\..\..\..\..\..\..\Middlewares\Third_Party\mcuboot\platform\ext\driver
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\..\Binary\oemirot_tz_ns_app.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32wbaxx_flash_ns.icf.i
  ILINK.IlinkAdditionalLibs: ..\Secure\NUCLEO-WBA25CE_S\Exe\Project_import_lib.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/User
    ../../NonSecure/Src/: com.c common.c fw_update_app.c low_level_device.c low_level_ext_flash.c low_level_extmem_device.c low_level_flash.c main.c mpu_armv8m_drv.c ns_data.c startup_stm32wbaxx.c stm32wbaxx_it.c ymodem.c
  group Doc
    ../../: README.md
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/mx25r3235f/: mx25r3235f.c
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo_xspi.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal.c stm32wbaxx_hal_cortex.c stm32wbaxx_hal_crc.c stm32wbaxx_hal_crc_ex.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_spi.c stm32wbaxx_hal_spi_ex.c stm32wbaxx_hal_uart.c stm32wbaxx_hal_uart_ex.c stm32wbaxx_hal_xspi.c stm32wbaxx_ll_dlyb.c
