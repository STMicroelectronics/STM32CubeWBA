<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Secure\TrustZoneEnabled_S.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\NonSecure\TrustZoneEnabled_NS.ewp</path>
  </project>
  <batchBuild />
</workspace>
