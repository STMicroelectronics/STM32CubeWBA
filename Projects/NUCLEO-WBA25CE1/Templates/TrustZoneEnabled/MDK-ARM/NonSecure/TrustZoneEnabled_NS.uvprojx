# Keil uVision project TrustZoneEnabled_NS.uvprojx, settings and files
target TrustZoneEnabled_NS (6220000::V6.22::ARMCLANG)
  device: STM32WBA25CEUx STMicroelectronics
  pack: Keil.STM32WBAxx_DFP.2.2.0-RC1
  cpu: IRAM(0x20008000-0x2000FFFF) IROM(0x08040000-0x807FFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: TrustZoneEnabled_NS +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WBA25xx
  c include: ../../NonSecure/Inc;../../Secure_nsclib;../../../../../../Drivers/BSP/STM32WBAxx_Nucleo;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32WBAxx/Include;../../../../../../Drivers/STM32WBAxx_HAL_Driver/Inc/Legacy;../../../../../../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8040000 size 0x40000
  memory RVCT9: RAM 0x20008000 size 0x8000
  scatter file: stm32wba25xx_flash_ns.sct
  link misc: ../../Secure_nsclib/secure_nsclib.o
--diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ../: startup_stm32wba25xx.s
  group Application/User/NonSecure
    ../../NonSecure/Src/: main.c stm32wbaxx_it.c stm32wbaxx_hal_msp.c
  group Doc
    ../../: README.md
  group Drivers/BSP/STM32WBAxx_Nucleo
    ../../../../../../Drivers/BSP/STM32WBAxx_Nucleo/: stm32wbaxx_nucleo.c
  group Drivers/STM32WBAxx_HAL_Driver
    ../../../../../../Drivers/STM32WBAxx_HAL_Driver/Src/: stm32wbaxx_hal_cortex.c stm32wbaxx_hal.c stm32wbaxx_hal_rcc.c stm32wbaxx_hal_rcc_ex.c stm32wbaxx_hal_flash.c stm32wbaxx_hal_flash_ex.c stm32wbaxx_hal_gpio.c stm32wbaxx_hal_dma.c stm32wbaxx_hal_dma_ex.c stm32wbaxx_hal_exti.c stm32wbaxx_hal_pwr.c stm32wbaxx_hal_pwr_ex.c
  group Drivers/CMSIS
    ../../NonSecure/Src/: system_stm32wbaxx_ns.c
software components: CMSIS:CORE 5.6.0
